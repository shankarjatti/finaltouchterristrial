options:
  parameters:
    author: AVGARDE SYSTEMS — SecureCOM M1
    description: Module 2 — 42-Channel Decoder with Combined Spectrum Analyzer
    generate_options: qt_gui
    id: securecom_module2_decoder
    output_language: python
    title: SecureCOM Module 2 — Multiband Real-Time Receiver
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: '36000'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[1-1j, 1+1j, -1-1j, 1-1j]'
    precision: '8'
    soft_dec_lut: '''auto'''
    type: dqpsk
  states: {}
- name: decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: freq_offset_khz
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,1]'
    label: Baseband offset [kHz]
    type: real
    value: '-1.714'
  states: {}
- name: frequency_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,0]'
    label: Frequency [MHz]
    type: real
    value: '467.5625'
  states: {}
- name: gain_demod
  id: variable_qtgui_range
  parameters:
    comment: DMR FM demod gain 1.0 -- measured optimum, offline decode test on real captured IQ (3.93 gave silence)
    label: FM Demod Gain (DMR)
    start: '0.05'
    step: '0.01'
    stop: '10.0'
    value: '1.0'
  states: {}
- name: gain_demod_nxdn
  id: variable_qtgui_range
  parameters:
    comment: NXDN96 gain = 48k/(2pi*1050Hz) = 7.28 (deviation to verify on air)
    label: FM Demod Gain (NXDN)
    start: '0.05'
    step: '0.01'
    stop: '14.0'
    value: '7.28'
  states: {}
- name: gain_demod_p25
  id: variable_qtgui_range
  parameters:
    comment: P25 C4FM gain = 48k/(2pi*1800Hz) = 4.24
    label: FM Demod Gain (P25)
    start: '0.05'
    step: '0.01'
    stop: '10.0'
    value: '4.24'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: ppm_corr
  id: variable_qtgui_range
  parameters:
    gui_hint: '[2,0,1,2]'
    label: PPM correction
    rangeType: int
    start: '-20'
    step: '1'
    stop: '15'
    value: '0'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 'TCP IQ from Module 1: 200 kSps'
    value: '200000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: squelch_thresh
  id: variable_qtgui_range
  parameters:
    comment: Channel Squelch Threshold (dB) — mutes idle channels
    label: Noise Squelch Threshold (dB)
    start: '-90'
    step: '1'
    stop: '-10'
    value: '-20'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: constel
    modulus: '1'
    step_size: '10e-3'
    type: cma
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: Audio Speech Output Volume
    label: Audio Volume Boost
    start: '0.01'
    step: '0.01'
    stop: '20.0'
    value: '0.04'
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '8'
    reference: '1'
  states: {}
- name: aresamp_dmr_ch0
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch0 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_dmr_ch1
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch1 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_dmr_ch10
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch10 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_dmr_ch11
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch11 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_dmr_ch12
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch12 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_dmr_ch13
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch13 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_dmr_ch14
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch14 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_dmr_ch15
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch15 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_dmr_ch2
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch2 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_dmr_ch3
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch3 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_dmr_ch4
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch4 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_dmr_ch5
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch5 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_dmr_ch6
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch6 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_dmr_ch7
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch7 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_dmr_ch8
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch8 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_dmr_ch9
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch9 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch0
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch0 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch1
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch1 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch10
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch10 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch11
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch11 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch12
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch12 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch13
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch13 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch14
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch14 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch15
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch15 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch2
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch2 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch3
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch3 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch4
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch4 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch5
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch5 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch6
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch6 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch7
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch7 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch8
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch8 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn_ch9
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch9 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_p25_ch0
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch0 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_p25_ch1
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch1 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_p25_ch2
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch2 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_p25_ch3
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch3 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_p25_ch4
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch4 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_p25_ch5
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch5 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_p25_ch6
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch6 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_p25_ch7
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch7 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_p25_ch8
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch8 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_p25_ch9
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch9 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: audio_mix_dmr
  id: blocks_add_xx
  parameters:
    comment: DMR446 16-ch audio mixer @ 48kSps
    maxoutbuf: '1024'
    num_inputs: '16'
    type: float
  states: {}
- name: audio_mix_nxdn
  id: blocks_add_xx
  parameters:
    comment: NXDN96 16-ch audio mixer @ 48kSps
    maxoutbuf: '1024'
    num_inputs: '16'
    type: float
  states: {}
- name: audio_mix_p25
  id: blocks_add_xx
  parameters:
    comment: P25 Phase 1 10-ch audio mixer @ 48kSps
    maxoutbuf: '1024'
    num_inputs: '10'
    type: float
  states: {}
- name: audio_mix_tetra
  id: blocks_add_xx
  parameters:
    comment: TETRA 4-timeslot combined audio (for convenience listening)
    maxoutbuf: '1024'
    num_inputs: '4'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: PulseAudio System Default Audio Sink
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: audio_sink_tetra_combined
  id: audio_sink
  parameters:
    comment: TETRA combined (all 4 slots mixed)
    samp_rate: '8000'
  states: {}
- name: audio_sink_tn1
  id: audio_sink
  parameters:
    comment: Timeslot 1
    samp_rate: '8000'
  states: {}
- name: audio_sink_tn2
  id: audio_sink
  parameters:
    comment: Timeslot 2
    samp_rate: '8000'
  states: {}
- name: audio_sink_tn3
  id: audio_sink
  parameters:
    comment: Timeslot 3
    samp_rate: '8000'
  states: {}
- name: audio_sink_tn4
  id: audio_sink
  parameters:
    comment: Timeslot 4
    samp_rate: '8000'
  states: {}
- name: blocks_add_master
  id: blocks_add_xx
  parameters:
    comment: Master 3-band audio mixer @ 48kSps
    maxoutbuf: '1024'
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: TETRA call log
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constel.bits_per_symbol()
  states: {}
- name: bridge_zmq_dmr
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:9101
    comment: 'bridge tap: real DMR combined audio @48k'
    timeout: '100'
    type: float
  states: {}
- name: bridge_zmq_nxdn
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:9102
    comment: 'bridge tap: real NXDN combined audio @48k'
    timeout: '100'
    type: float
  states: {}
- name: bridge_zmq_p25
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:9103
    comment: 'bridge tap: real P25 combined audio @48k'
    timeout: '100'
    type: float
  states: {}
- name: bridge_zmq_tetra
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:9104
    comment: 'bridge tap: real TETRA combined audio @8k'
    timeout: '100'
    type: float
  states: {}
- name: bridge_zmq_tetra_events
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:9105
    comment: 'bridge tap: real TETRA call_log events'
    timeout: '100'
  states: {}
- name: demod_dmr_ch0
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch0 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_dmr_ch1
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch1 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_dmr_ch10
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch10 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_dmr_ch11
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch11 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_dmr_ch12
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch12 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_dmr_ch13
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch13 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_dmr_ch14
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch14 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_dmr_ch15
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch15 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_dmr_ch2
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch2 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_dmr_ch3
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch3 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_dmr_ch4
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch4 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_dmr_ch5
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch5 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_dmr_ch6
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch6 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_dmr_ch7
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch7 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_dmr_ch8
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch8 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_dmr_ch9
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch9 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch0
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch0 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch1
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch1 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch10
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch10 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch11
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch11 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch12
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch12 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch13
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch13 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch14
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch14 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch15
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch15 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch2
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch2 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch3
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch3 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch4
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch4 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch5
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch5 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch6
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch6 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch7
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch7 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch8
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch8 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn_ch9
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch9 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_p25_ch0
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch0 FM Demodulator (gain=0.2)
    gain: gain_demod_p25
    maxoutbuf: '1024'
  states: {}
- name: demod_p25_ch1
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch1 FM Demodulator (gain=0.2)
    gain: gain_demod_p25
    maxoutbuf: '1024'
  states: {}
- name: demod_p25_ch2
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch2 FM Demodulator (gain=0.2)
    gain: gain_demod_p25
    maxoutbuf: '1024'
  states: {}
- name: demod_p25_ch3
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch3 FM Demodulator (gain=0.2)
    gain: gain_demod_p25
    maxoutbuf: '1024'
  states: {}
- name: demod_p25_ch4
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch4 FM Demodulator (gain=0.2)
    gain: gain_demod_p25
    maxoutbuf: '1024'
  states: {}
- name: demod_p25_ch5
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch5 FM Demodulator (gain=0.2)
    gain: gain_demod_p25
    maxoutbuf: '1024'
  states: {}
- name: demod_p25_ch6
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch6 FM Demodulator (gain=0.2)
    gain: gain_demod_p25
    maxoutbuf: '1024'
  states: {}
- name: demod_p25_ch7
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch7 FM Demodulator (gain=0.2)
    gain: gain_demod_p25
    maxoutbuf: '1024'
  states: {}
- name: demod_p25_ch8
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch8 FM Demodulator (gain=0.2)
    gain: gain_demod_p25
    maxoutbuf: '1024'
  states: {}
- name: demod_p25_ch9
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch9 FM Demodulator (gain=0.2)
    gain: gain_demod_p25
    maxoutbuf: '1024'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters: {}
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '45'
    rolloff: '0.35'
    samps_per_sym: sps
    type: cc
    w: '0.03141592653589793'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: sps
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: constel.pre_diff_code()
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.06283185307179586'
    max_dev: '1.5'
    osps: sps
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: dsd_dmr_ch0
  id: dsd_block_ff
  parameters:
    comment: DMR ch0 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_dmr_ch1
  id: dsd_block_ff
  parameters:
    comment: DMR ch1 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_dmr_ch10
  id: dsd_block_ff
  parameters:
    comment: DMR ch10 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_dmr_ch11
  id: dsd_block_ff
  parameters:
    comment: DMR ch11 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_dmr_ch12
  id: dsd_block_ff
  parameters:
    comment: DMR ch12 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_dmr_ch13
  id: dsd_block_ff
  parameters:
    comment: DMR ch13 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_dmr_ch14
  id: dsd_block_ff
  parameters:
    comment: DMR ch14 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_dmr_ch15
  id: dsd_block_ff
  parameters:
    comment: DMR ch15 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_dmr_ch2
  id: dsd_block_ff
  parameters:
    comment: DMR ch2 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_dmr_ch3
  id: dsd_block_ff
  parameters:
    comment: DMR ch3 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_dmr_ch4
  id: dsd_block_ff
  parameters:
    comment: DMR ch4 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_dmr_ch5
  id: dsd_block_ff
  parameters:
    comment: DMR ch5 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_dmr_ch6
  id: dsd_block_ff
  parameters:
    comment: DMR ch6 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_dmr_ch7
  id: dsd_block_ff
  parameters:
    comment: DMR ch7 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_dmr_ch8
  id: dsd_block_ff
  parameters:
    comment: DMR ch8 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_dmr_ch9
  id: dsd_block_ff
  parameters:
    comment: DMR ch9 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch0
  id: dsd_block_ff
  parameters:
    comment: NXDN ch0 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch1
  id: dsd_block_ff
  parameters:
    comment: NXDN ch1 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch10
  id: dsd_block_ff
  parameters:
    comment: NXDN ch10 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch11
  id: dsd_block_ff
  parameters:
    comment: NXDN ch11 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch12
  id: dsd_block_ff
  parameters:
    comment: NXDN ch12 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch13
  id: dsd_block_ff
  parameters:
    comment: NXDN ch13 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch14
  id: dsd_block_ff
  parameters:
    comment: NXDN ch14 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch15
  id: dsd_block_ff
  parameters:
    comment: NXDN ch15 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch2
  id: dsd_block_ff
  parameters:
    comment: NXDN ch2 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch3
  id: dsd_block_ff
  parameters:
    comment: NXDN ch3 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch4
  id: dsd_block_ff
  parameters:
    comment: NXDN ch4 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch5
  id: dsd_block_ff
  parameters:
    comment: NXDN ch5 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch6
  id: dsd_block_ff
  parameters:
    comment: NXDN ch6 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch7
  id: dsd_block_ff
  parameters:
    comment: NXDN ch7 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch8
  id: dsd_block_ff
  parameters:
    comment: NXDN ch8 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn_ch9
  id: dsd_block_ff
  parameters:
    comment: NXDN ch9 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_p25_ch0
  id: dsd_block_ff
  parameters:
    comment: P25 ch0 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_p25_ch1
  id: dsd_block_ff
  parameters:
    comment: P25 ch1 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_p25_ch2
  id: dsd_block_ff
  parameters:
    comment: P25 ch2 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_p25_ch3
  id: dsd_block_ff
  parameters:
    comment: P25 ch3 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_p25_ch4
  id: dsd_block_ff
  parameters:
    comment: P25 ch4 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_p25_ch5
  id: dsd_block_ff
  parameters:
    comment: P25 ch5 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_p25_ch6
  id: dsd_block_ff
  parameters:
    comment: P25 ch6 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_p25_ch7
  id: dsd_block_ff
  parameters:
    comment: P25 ch7 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_p25_ch8
  id: dsd_block_ff
  parameters:
    comment: P25 ch8 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_p25_ch9
  id: dsd_block_ff
  parameters:
    comment: P25 ch9 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset_khz*1e3
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,12500,12500*0.2)
    type: ccc
  states: {}
- name: lpf_dmr_ch0
  id: low_pass_filter
  parameters:
    comment: DMR ch0 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_dmr_ch1
  id: low_pass_filter
  parameters:
    comment: DMR ch1 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_dmr_ch10
  id: low_pass_filter
  parameters:
    comment: DMR ch10 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_dmr_ch11
  id: low_pass_filter
  parameters:
    comment: DMR ch11 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_dmr_ch12
  id: low_pass_filter
  parameters:
    comment: DMR ch12 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_dmr_ch13
  id: low_pass_filter
  parameters:
    comment: DMR ch13 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_dmr_ch14
  id: low_pass_filter
  parameters:
    comment: DMR ch14 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_dmr_ch15
  id: low_pass_filter
  parameters:
    comment: DMR ch15 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_dmr_ch2
  id: low_pass_filter
  parameters:
    comment: DMR ch2 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_dmr_ch3
  id: low_pass_filter
  parameters:
    comment: DMR ch3 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_dmr_ch4
  id: low_pass_filter
  parameters:
    comment: DMR ch4 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_dmr_ch5
  id: low_pass_filter
  parameters:
    comment: DMR ch5 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_dmr_ch6
  id: low_pass_filter
  parameters:
    comment: DMR ch6 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_dmr_ch7
  id: low_pass_filter
  parameters:
    comment: DMR ch7 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_dmr_ch8
  id: low_pass_filter
  parameters:
    comment: DMR ch8 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_dmr_ch9
  id: low_pass_filter
  parameters:
    comment: DMR ch9 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch0
  id: low_pass_filter
  parameters:
    comment: NXDN ch0 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch1
  id: low_pass_filter
  parameters:
    comment: NXDN ch1 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch10
  id: low_pass_filter
  parameters:
    comment: NXDN ch10 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch11
  id: low_pass_filter
  parameters:
    comment: NXDN ch11 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch12
  id: low_pass_filter
  parameters:
    comment: NXDN ch12 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch13
  id: low_pass_filter
  parameters:
    comment: NXDN ch13 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch14
  id: low_pass_filter
  parameters:
    comment: NXDN ch14 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch15
  id: low_pass_filter
  parameters:
    comment: NXDN ch15 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch2
  id: low_pass_filter
  parameters:
    comment: NXDN ch2 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch3
  id: low_pass_filter
  parameters:
    comment: NXDN ch3 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch4
  id: low_pass_filter
  parameters:
    comment: NXDN ch4 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch5
  id: low_pass_filter
  parameters:
    comment: NXDN ch5 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch6
  id: low_pass_filter
  parameters:
    comment: NXDN ch6 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch7
  id: low_pass_filter
  parameters:
    comment: NXDN ch7 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch8
  id: low_pass_filter
  parameters:
    comment: NXDN ch8 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn_ch9
  id: low_pass_filter
  parameters:
    comment: NXDN ch9 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_p25_ch0
  id: low_pass_filter
  parameters:
    comment: P25 ch0 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_p25_ch1
  id: low_pass_filter
  parameters:
    comment: P25 ch1 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_p25_ch2
  id: low_pass_filter
  parameters:
    comment: P25 ch2 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_p25_ch3
  id: low_pass_filter
  parameters:
    comment: P25 ch3 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_p25_ch4
  id: low_pass_filter
  parameters:
    comment: P25 ch4 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_p25_ch5
  id: low_pass_filter
  parameters:
    comment: P25 ch5 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_p25_ch6
  id: low_pass_filter
  parameters:
    comment: P25 ch6 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_p25_ch7
  id: low_pass_filter
  parameters:
    comment: P25 ch7 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_p25_ch8
  id: low_pass_filter
  parameters:
    comment: P25 ch8 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_p25_ch9
  id: low_pass_filter
  parameters:
    comment: P25 ch9 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(samp_rate)/(float(decim)*float(channel_rate))
    type: complex
  states: {}
- name: network_tcp_source_dmr
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: TCP 127.0.0.1:7001 — DMR446 446.09375MHz
    maxoutbuf: '1024'
    port: '7001'
    server: 'False'
    type: complex
  states: {}
- name: network_tcp_source_nxdn
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: TCP 127.0.0.1:7002 — NXDN96 451.09375MHz
    maxoutbuf: '1024'
    port: '7002'
    server: 'False'
    type: complex
  states: {}
- name: network_tcp_source_p25
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: TCP 127.0.0.1:7003 — P25 Phase 1 450.09375MHz
    maxoutbuf: '1024'
    port: '7003'
    server: 'False'
    type: complex
  states: {}
- name: network_tcp_source_tetra
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: TCP 127.0.0.1:7004 — TETRA 420.0MHz
    maxoutbuf: '1024'
    port: '7004'
    server: 'False'
    type: complex
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    comment: DMR446 16ch @ 12.5kSps/ch
    maxoutbuf: '1024'
    nchans: '16'
    osr: '1.0'
    taps: firdes.low_pass(16.0, samp_rate, (samp_rate/16.0)/2.0, 1000)
  states: {}
- name: pfb_channelizer_ccf_0_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    comment: P25 Phase 1 10ch @ 20kSps/ch
    maxoutbuf: '1024'
    nchans: '10'
    osr: '1.0'
    taps: firdes.low_pass(10.0, samp_rate, (samp_rate/10.0)/2.0, 1000)
  states: {}
- name: pfb_channelizer_ccf_0_1
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    comment: NXDN96 16ch @ 12.5kSps/ch
    maxoutbuf: '1024'
    nchans: '16'
    osr: '1.0'
    taps: firdes.low_pass(16.0, samp_rate, (samp_rate/16.0)/2.0, 1000)
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: '[4,0,1,2]'
    label1: Data 0
    legend: 'False'
    name: output
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_combined
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    comment: Combined Spectrum Analyzer for All 3 Bands
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label: Power Spectrum Density
    label1: DMR446 (Port 7001)
    label2: NXDN96 (Port 7002)
    label3: P25 Phase 1 (Port 7003)
    label4: TETRA (Port 7004)
    name: SecureCOM Live Spectrum Activity (Blue=DMR, Red=NXDN, Green=P25)
    nconnections: '4'
    tr_tag: ''
    type: complex
    width1: '2'
    width2: '2'
    width3: '2'
  states: {}
- name: qtgui_time_sink_dnp
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: audio
    name: Audio Time Domain — DMR/NXDN/P25
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_tetra
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: audio
    name: Audio Time Domain — TETRA
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: channel_rate
    fc: '0'
    fftsize: '256'
    gui_hint: '[3,0,1,2]'
    label1: Data 0
    type: complex
    update_time: '0.1'
  states: {}
- name: resamp_iq_dmr_ch0
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch0: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_dmr_ch1
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch1: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_dmr_ch10
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch10: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_dmr_ch11
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch11: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_dmr_ch12
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch12: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_dmr_ch13
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch13: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_dmr_ch14
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch14: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_dmr_ch15
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch15: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_dmr_ch2
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch2: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_dmr_ch3
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch3: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_dmr_ch4
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch4: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_dmr_ch5
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch5: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_dmr_ch6
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch6: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_dmr_ch7
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch7: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_dmr_ch8
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch8: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_dmr_ch9
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch9: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch0
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch0: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch1
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch1: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch10
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch10: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch11
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch11: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch12
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch12: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch13
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch13: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch14
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch14: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch15
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch15: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch2
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch2: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch3
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch3: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch4
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch4: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch5
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch5: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch6
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch6: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch7
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch7: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch8
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch8: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn_ch9
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch9: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_p25_ch0
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch0: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_p25_ch1
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch1: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_p25_ch2
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch2: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_p25_ch3
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch3: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_p25_ch4
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch4: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_p25_ch5
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch5: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_p25_ch6
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch6: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_p25_ch7
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch7: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_p25_ch8
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch8: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_p25_ch9
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch9: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: squelch_dmr_ch0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch0 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_dmr_ch1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch1 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_dmr_ch10
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch10 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_dmr_ch11
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch11 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_dmr_ch12
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch12 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_dmr_ch13
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch13 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_dmr_ch14
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch14 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_dmr_ch15
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch15 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_dmr_ch2
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch2 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_dmr_ch3
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch3 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_dmr_ch4
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch4 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_dmr_ch5
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch5 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_dmr_ch6
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch6 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_dmr_ch7
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch7 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_dmr_ch8
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch8 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_dmr_ch9
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch9 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch0 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch1 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch10
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch10 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch11
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch11 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch12
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch12 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch13
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch13 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch14
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch14 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch15
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch15 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch2
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch2 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch3
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch3 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch4
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch4 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch5
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch5 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch6
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch6 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch7
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch7 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch8
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch8 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_nxdn_ch9
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch9 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_p25_ch0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch0 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_p25_ch1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch1 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_p25_ch2
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch2 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_p25_ch3
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch3 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_p25_ch4
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch4 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_p25_ch5
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch5 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_p25_ch6
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch6 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_p25_ch7
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch7 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_p25_ch8
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch8 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: squelch_p25_ch9
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch9 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {}
- name: tetra_decoder_block_0
  id: tetra_decoder_block
  parameters:
    comment: in-flowgraph tetra-kit + ACELP decode, no external process
    debug: 'True'
    log_level: '1'
    remove_fill_bits: 'True'
    wireshark_output: 'False'
  states: {}
- name: vol_dmr_ch0
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch0 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_dmr_ch1
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch1 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_dmr_ch10
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch10 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_dmr_ch11
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch11 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_dmr_ch12
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch12 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_dmr_ch13
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch13 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_dmr_ch14
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch14 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_dmr_ch15
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch15 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_dmr_ch2
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch2 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_dmr_ch3
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch3 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_dmr_ch4
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch4 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_dmr_ch5
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch5 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_dmr_ch6
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch6 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_dmr_ch7
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch7 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_dmr_ch8
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch8 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_dmr_ch9
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch9 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch0
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch0 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch1
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch1 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch10
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch10 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch11
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch11 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch12
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch12 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch13
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch13 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch14
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch14 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch15
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch15 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch2
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch2 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch3
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch3 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch4
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch4 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch5
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch5 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch6
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch6 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch7
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch7 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch8
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch8 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn_ch9
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch9 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_p25_ch0
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch0 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_p25_ch1
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch1 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_p25_ch2
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch2 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_p25_ch3
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch3 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_p25_ch4
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch4 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_p25_ch5
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch5 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_p25_ch6
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch6 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_p25_ch7
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch7 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_p25_ch8
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch8 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_p25_ch9
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch9 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {}

connections:
- [analog_feedforward_agc_cc_0, '0', digital_fll_band_edge_cc_0, '0']
- [aresamp_dmr_ch0, '0', vol_dmr_ch0, '0']
- [aresamp_dmr_ch1, '0', vol_dmr_ch1, '0']
- [aresamp_dmr_ch10, '0', vol_dmr_ch10, '0']
- [aresamp_dmr_ch11, '0', vol_dmr_ch11, '0']
- [aresamp_dmr_ch12, '0', vol_dmr_ch12, '0']
- [aresamp_dmr_ch13, '0', vol_dmr_ch13, '0']
- [aresamp_dmr_ch14, '0', vol_dmr_ch14, '0']
- [aresamp_dmr_ch15, '0', vol_dmr_ch15, '0']
- [aresamp_dmr_ch2, '0', vol_dmr_ch2, '0']
- [aresamp_dmr_ch3, '0', vol_dmr_ch3, '0']
- [aresamp_dmr_ch4, '0', vol_dmr_ch4, '0']
- [aresamp_dmr_ch5, '0', vol_dmr_ch5, '0']
- [aresamp_dmr_ch6, '0', vol_dmr_ch6, '0']
- [aresamp_dmr_ch7, '0', vol_dmr_ch7, '0']
- [aresamp_dmr_ch8, '0', vol_dmr_ch8, '0']
- [aresamp_dmr_ch9, '0', vol_dmr_ch9, '0']
- [aresamp_nxdn_ch0, '0', vol_nxdn_ch0, '0']
- [aresamp_nxdn_ch1, '0', vol_nxdn_ch1, '0']
- [aresamp_nxdn_ch10, '0', vol_nxdn_ch10, '0']
- [aresamp_nxdn_ch11, '0', vol_nxdn_ch11, '0']
- [aresamp_nxdn_ch12, '0', vol_nxdn_ch12, '0']
- [aresamp_nxdn_ch13, '0', vol_nxdn_ch13, '0']
- [aresamp_nxdn_ch14, '0', vol_nxdn_ch14, '0']
- [aresamp_nxdn_ch15, '0', vol_nxdn_ch15, '0']
- [aresamp_nxdn_ch2, '0', vol_nxdn_ch2, '0']
- [aresamp_nxdn_ch3, '0', vol_nxdn_ch3, '0']
- [aresamp_nxdn_ch4, '0', vol_nxdn_ch4, '0']
- [aresamp_nxdn_ch5, '0', vol_nxdn_ch5, '0']
- [aresamp_nxdn_ch6, '0', vol_nxdn_ch6, '0']
- [aresamp_nxdn_ch7, '0', vol_nxdn_ch7, '0']
- [aresamp_nxdn_ch8, '0', vol_nxdn_ch8, '0']
- [aresamp_nxdn_ch9, '0', vol_nxdn_ch9, '0']
- [aresamp_p25_ch0, '0', vol_p25_ch0, '0']
- [aresamp_p25_ch1, '0', vol_p25_ch1, '0']
- [aresamp_p25_ch2, '0', vol_p25_ch2, '0']
- [aresamp_p25_ch3, '0', vol_p25_ch3, '0']
- [aresamp_p25_ch4, '0', vol_p25_ch4, '0']
- [aresamp_p25_ch5, '0', vol_p25_ch5, '0']
- [aresamp_p25_ch6, '0', vol_p25_ch6, '0']
- [aresamp_p25_ch7, '0', vol_p25_ch7, '0']
- [aresamp_p25_ch8, '0', vol_p25_ch8, '0']
- [aresamp_p25_ch9, '0', vol_p25_ch9, '0']
- [audio_mix_dmr, '0', blocks_add_master, '0']
- [audio_mix_dmr, '0', bridge_zmq_dmr, '0']
- [audio_mix_nxdn, '0', blocks_add_master, '1']
- [audio_mix_nxdn, '0', bridge_zmq_nxdn, '0']
- [audio_mix_p25, '0', blocks_add_master, '2']
- [audio_mix_p25, '0', bridge_zmq_p25, '0']
- [audio_mix_tetra, '0', audio_sink_tetra_combined, '0']
- [audio_mix_tetra, '0', bridge_zmq_tetra, '0']
- [audio_mix_tetra, '0', qtgui_time_sink_tetra, '0']
- [blocks_add_master, '0', audio_sink_0, '0']
- [blocks_add_master, '0', qtgui_time_sink_dnp, '0']
- [blocks_unpack_k_bits_bb_0, '0', tetra_decoder_block_0, '0']
- [demod_dmr_ch0, '0', dsd_dmr_ch0, '0']
- [demod_dmr_ch1, '0', dsd_dmr_ch1, '0']
- [demod_dmr_ch10, '0', dsd_dmr_ch10, '0']
- [demod_dmr_ch11, '0', dsd_dmr_ch11, '0']
- [demod_dmr_ch12, '0', dsd_dmr_ch12, '0']
- [demod_dmr_ch13, '0', dsd_dmr_ch13, '0']
- [demod_dmr_ch14, '0', dsd_dmr_ch14, '0']
- [demod_dmr_ch15, '0', dsd_dmr_ch15, '0']
- [demod_dmr_ch2, '0', dsd_dmr_ch2, '0']
- [demod_dmr_ch3, '0', dsd_dmr_ch3, '0']
- [demod_dmr_ch4, '0', dsd_dmr_ch4, '0']
- [demod_dmr_ch5, '0', dsd_dmr_ch5, '0']
- [demod_dmr_ch6, '0', dsd_dmr_ch6, '0']
- [demod_dmr_ch7, '0', dsd_dmr_ch7, '0']
- [demod_dmr_ch8, '0', dsd_dmr_ch8, '0']
- [demod_dmr_ch9, '0', dsd_dmr_ch9, '0']
- [demod_nxdn_ch0, '0', dsd_nxdn_ch0, '0']
- [demod_nxdn_ch1, '0', dsd_nxdn_ch1, '0']
- [demod_nxdn_ch10, '0', dsd_nxdn_ch10, '0']
- [demod_nxdn_ch11, '0', dsd_nxdn_ch11, '0']
- [demod_nxdn_ch12, '0', dsd_nxdn_ch12, '0']
- [demod_nxdn_ch13, '0', dsd_nxdn_ch13, '0']
- [demod_nxdn_ch14, '0', dsd_nxdn_ch14, '0']
- [demod_nxdn_ch15, '0', dsd_nxdn_ch15, '0']
- [demod_nxdn_ch2, '0', dsd_nxdn_ch2, '0']
- [demod_nxdn_ch3, '0', dsd_nxdn_ch3, '0']
- [demod_nxdn_ch4, '0', dsd_nxdn_ch4, '0']
- [demod_nxdn_ch5, '0', dsd_nxdn_ch5, '0']
- [demod_nxdn_ch6, '0', dsd_nxdn_ch6, '0']
- [demod_nxdn_ch7, '0', dsd_nxdn_ch7, '0']
- [demod_nxdn_ch8, '0', dsd_nxdn_ch8, '0']
- [demod_nxdn_ch9, '0', dsd_nxdn_ch9, '0']
- [demod_p25_ch0, '0', dsd_p25_ch0, '0']
- [demod_p25_ch1, '0', dsd_p25_ch1, '0']
- [demod_p25_ch2, '0', dsd_p25_ch2, '0']
- [demod_p25_ch3, '0', dsd_p25_ch3, '0']
- [demod_p25_ch4, '0', dsd_p25_ch4, '0']
- [demod_p25_ch5, '0', dsd_p25_ch5, '0']
- [demod_p25_ch6, '0', dsd_p25_ch6, '0']
- [demod_p25_ch7, '0', dsd_p25_ch7, '0']
- [demod_p25_ch8, '0', dsd_p25_ch8, '0']
- [demod_p25_ch9, '0', dsd_p25_ch9, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_diff_phasor_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_diff_phasor_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_linear_equalizer_0, '0', digital_diff_phasor_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [dsd_dmr_ch0, '0', aresamp_dmr_ch0, '0']
- [dsd_dmr_ch1, '0', aresamp_dmr_ch1, '0']
- [dsd_dmr_ch10, '0', aresamp_dmr_ch10, '0']
- [dsd_dmr_ch11, '0', aresamp_dmr_ch11, '0']
- [dsd_dmr_ch12, '0', aresamp_dmr_ch12, '0']
- [dsd_dmr_ch13, '0', aresamp_dmr_ch13, '0']
- [dsd_dmr_ch14, '0', aresamp_dmr_ch14, '0']
- [dsd_dmr_ch15, '0', aresamp_dmr_ch15, '0']
- [dsd_dmr_ch2, '0', aresamp_dmr_ch2, '0']
- [dsd_dmr_ch3, '0', aresamp_dmr_ch3, '0']
- [dsd_dmr_ch4, '0', aresamp_dmr_ch4, '0']
- [dsd_dmr_ch5, '0', aresamp_dmr_ch5, '0']
- [dsd_dmr_ch6, '0', aresamp_dmr_ch6, '0']
- [dsd_dmr_ch7, '0', aresamp_dmr_ch7, '0']
- [dsd_dmr_ch8, '0', aresamp_dmr_ch8, '0']
- [dsd_dmr_ch9, '0', aresamp_dmr_ch9, '0']
- [dsd_nxdn_ch0, '0', aresamp_nxdn_ch0, '0']
- [dsd_nxdn_ch1, '0', aresamp_nxdn_ch1, '0']
- [dsd_nxdn_ch10, '0', aresamp_nxdn_ch10, '0']
- [dsd_nxdn_ch11, '0', aresamp_nxdn_ch11, '0']
- [dsd_nxdn_ch12, '0', aresamp_nxdn_ch12, '0']
- [dsd_nxdn_ch13, '0', aresamp_nxdn_ch13, '0']
- [dsd_nxdn_ch14, '0', aresamp_nxdn_ch14, '0']
- [dsd_nxdn_ch15, '0', aresamp_nxdn_ch15, '0']
- [dsd_nxdn_ch2, '0', aresamp_nxdn_ch2, '0']
- [dsd_nxdn_ch3, '0', aresamp_nxdn_ch3, '0']
- [dsd_nxdn_ch4, '0', aresamp_nxdn_ch4, '0']
- [dsd_nxdn_ch5, '0', aresamp_nxdn_ch5, '0']
- [dsd_nxdn_ch6, '0', aresamp_nxdn_ch6, '0']
- [dsd_nxdn_ch7, '0', aresamp_nxdn_ch7, '0']
- [dsd_nxdn_ch8, '0', aresamp_nxdn_ch8, '0']
- [dsd_nxdn_ch9, '0', aresamp_nxdn_ch9, '0']
- [dsd_p25_ch0, '0', aresamp_p25_ch0, '0']
- [dsd_p25_ch1, '0', aresamp_p25_ch1, '0']
- [dsd_p25_ch2, '0', aresamp_p25_ch2, '0']
- [dsd_p25_ch3, '0', aresamp_p25_ch3, '0']
- [dsd_p25_ch4, '0', aresamp_p25_ch4, '0']
- [dsd_p25_ch5, '0', aresamp_p25_ch5, '0']
- [dsd_p25_ch6, '0', aresamp_p25_ch6, '0']
- [dsd_p25_ch7, '0', aresamp_p25_ch7, '0']
- [dsd_p25_ch8, '0', aresamp_p25_ch8, '0']
- [dsd_p25_ch9, '0', aresamp_p25_ch9, '0']
- [freq_xlating_fir_filter_xxx_0, '0', mmse_resampler_xx_0, '0']
- [lpf_dmr_ch0, '0', squelch_dmr_ch0, '0']
- [lpf_dmr_ch1, '0', squelch_dmr_ch1, '0']
- [lpf_dmr_ch10, '0', squelch_dmr_ch10, '0']
- [lpf_dmr_ch11, '0', squelch_dmr_ch11, '0']
- [lpf_dmr_ch12, '0', squelch_dmr_ch12, '0']
- [lpf_dmr_ch13, '0', squelch_dmr_ch13, '0']
- [lpf_dmr_ch14, '0', squelch_dmr_ch14, '0']
- [lpf_dmr_ch15, '0', squelch_dmr_ch15, '0']
- [lpf_dmr_ch2, '0', squelch_dmr_ch2, '0']
- [lpf_dmr_ch3, '0', squelch_dmr_ch3, '0']
- [lpf_dmr_ch4, '0', squelch_dmr_ch4, '0']
- [lpf_dmr_ch5, '0', squelch_dmr_ch5, '0']
- [lpf_dmr_ch6, '0', squelch_dmr_ch6, '0']
- [lpf_dmr_ch7, '0', squelch_dmr_ch7, '0']
- [lpf_dmr_ch8, '0', squelch_dmr_ch8, '0']
- [lpf_dmr_ch9, '0', squelch_dmr_ch9, '0']
- [lpf_nxdn_ch0, '0', squelch_nxdn_ch0, '0']
- [lpf_nxdn_ch1, '0', squelch_nxdn_ch1, '0']
- [lpf_nxdn_ch10, '0', squelch_nxdn_ch10, '0']
- [lpf_nxdn_ch11, '0', squelch_nxdn_ch11, '0']
- [lpf_nxdn_ch12, '0', squelch_nxdn_ch12, '0']
- [lpf_nxdn_ch13, '0', squelch_nxdn_ch13, '0']
- [lpf_nxdn_ch14, '0', squelch_nxdn_ch14, '0']
- [lpf_nxdn_ch15, '0', squelch_nxdn_ch15, '0']
- [lpf_nxdn_ch2, '0', squelch_nxdn_ch2, '0']
- [lpf_nxdn_ch3, '0', squelch_nxdn_ch3, '0']
- [lpf_nxdn_ch4, '0', squelch_nxdn_ch4, '0']
- [lpf_nxdn_ch5, '0', squelch_nxdn_ch5, '0']
- [lpf_nxdn_ch6, '0', squelch_nxdn_ch6, '0']
- [lpf_nxdn_ch7, '0', squelch_nxdn_ch7, '0']
- [lpf_nxdn_ch8, '0', squelch_nxdn_ch8, '0']
- [lpf_nxdn_ch9, '0', squelch_nxdn_ch9, '0']
- [lpf_p25_ch0, '0', squelch_p25_ch0, '0']
- [lpf_p25_ch1, '0', squelch_p25_ch1, '0']
- [lpf_p25_ch2, '0', squelch_p25_ch2, '0']
- [lpf_p25_ch3, '0', squelch_p25_ch3, '0']
- [lpf_p25_ch4, '0', squelch_p25_ch4, '0']
- [lpf_p25_ch5, '0', squelch_p25_ch5, '0']
- [lpf_p25_ch6, '0', squelch_p25_ch6, '0']
- [lpf_p25_ch7, '0', squelch_p25_ch7, '0']
- [lpf_p25_ch8, '0', squelch_p25_ch8, '0']
- [lpf_p25_ch9, '0', squelch_p25_ch9, '0']
- [mmse_resampler_xx_0, '0', analog_feedforward_agc_cc_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [network_tcp_source_dmr, '0', pfb_channelizer_ccf_0, '0']
- [network_tcp_source_dmr, '0', qtgui_freq_sink_combined, '0']
- [network_tcp_source_nxdn, '0', pfb_channelizer_ccf_0_1, '0']
- [network_tcp_source_nxdn, '0', qtgui_freq_sink_combined, '1']
- [network_tcp_source_p25, '0', pfb_channelizer_ccf_0_0, '0']
- [network_tcp_source_p25, '0', qtgui_freq_sink_combined, '2']
- [network_tcp_source_tetra, '0', freq_xlating_fir_filter_xxx_0, '0']
- [network_tcp_source_tetra, '0', qtgui_freq_sink_combined, '3']
- [pfb_channelizer_ccf_0, '0', resamp_iq_dmr_ch0, '0']
- [pfb_channelizer_ccf_0, '1', resamp_iq_dmr_ch1, '0']
- [pfb_channelizer_ccf_0, '10', resamp_iq_dmr_ch10, '0']
- [pfb_channelizer_ccf_0, '11', resamp_iq_dmr_ch11, '0']
- [pfb_channelizer_ccf_0, '12', resamp_iq_dmr_ch12, '0']
- [pfb_channelizer_ccf_0, '13', resamp_iq_dmr_ch13, '0']
- [pfb_channelizer_ccf_0, '14', resamp_iq_dmr_ch14, '0']
- [pfb_channelizer_ccf_0, '15', resamp_iq_dmr_ch15, '0']
- [pfb_channelizer_ccf_0, '2', resamp_iq_dmr_ch2, '0']
- [pfb_channelizer_ccf_0, '3', resamp_iq_dmr_ch3, '0']
- [pfb_channelizer_ccf_0, '4', resamp_iq_dmr_ch4, '0']
- [pfb_channelizer_ccf_0, '5', resamp_iq_dmr_ch5, '0']
- [pfb_channelizer_ccf_0, '6', resamp_iq_dmr_ch6, '0']
- [pfb_channelizer_ccf_0, '7', resamp_iq_dmr_ch7, '0']
- [pfb_channelizer_ccf_0, '8', resamp_iq_dmr_ch8, '0']
- [pfb_channelizer_ccf_0, '9', resamp_iq_dmr_ch9, '0']
- [pfb_channelizer_ccf_0_0, '0', resamp_iq_p25_ch0, '0']
- [pfb_channelizer_ccf_0_0, '1', resamp_iq_p25_ch1, '0']
- [pfb_channelizer_ccf_0_0, '2', resamp_iq_p25_ch2, '0']
- [pfb_channelizer_ccf_0_0, '3', resamp_iq_p25_ch3, '0']
- [pfb_channelizer_ccf_0_0, '4', resamp_iq_p25_ch4, '0']
- [pfb_channelizer_ccf_0_0, '5', resamp_iq_p25_ch5, '0']
- [pfb_channelizer_ccf_0_0, '6', resamp_iq_p25_ch6, '0']
- [pfb_channelizer_ccf_0_0, '7', resamp_iq_p25_ch7, '0']
- [pfb_channelizer_ccf_0_0, '8', resamp_iq_p25_ch8, '0']
- [pfb_channelizer_ccf_0_0, '9', resamp_iq_p25_ch9, '0']
- [pfb_channelizer_ccf_0_1, '0', resamp_iq_nxdn_ch0, '0']
- [pfb_channelizer_ccf_0_1, '1', resamp_iq_nxdn_ch1, '0']
- [pfb_channelizer_ccf_0_1, '10', resamp_iq_nxdn_ch10, '0']
- [pfb_channelizer_ccf_0_1, '11', resamp_iq_nxdn_ch11, '0']
- [pfb_channelizer_ccf_0_1, '12', resamp_iq_nxdn_ch12, '0']
- [pfb_channelizer_ccf_0_1, '13', resamp_iq_nxdn_ch13, '0']
- [pfb_channelizer_ccf_0_1, '14', resamp_iq_nxdn_ch14, '0']
- [pfb_channelizer_ccf_0_1, '15', resamp_iq_nxdn_ch15, '0']
- [pfb_channelizer_ccf_0_1, '2', resamp_iq_nxdn_ch2, '0']
- [pfb_channelizer_ccf_0_1, '3', resamp_iq_nxdn_ch3, '0']
- [pfb_channelizer_ccf_0_1, '4', resamp_iq_nxdn_ch4, '0']
- [pfb_channelizer_ccf_0_1, '5', resamp_iq_nxdn_ch5, '0']
- [pfb_channelizer_ccf_0_1, '6', resamp_iq_nxdn_ch6, '0']
- [pfb_channelizer_ccf_0_1, '7', resamp_iq_nxdn_ch7, '0']
- [pfb_channelizer_ccf_0_1, '8', resamp_iq_nxdn_ch8, '0']
- [pfb_channelizer_ccf_0_1, '9', resamp_iq_nxdn_ch9, '0']
- [resamp_iq_dmr_ch0, '0', lpf_dmr_ch0, '0']
- [resamp_iq_dmr_ch1, '0', lpf_dmr_ch1, '0']
- [resamp_iq_dmr_ch10, '0', lpf_dmr_ch10, '0']
- [resamp_iq_dmr_ch11, '0', lpf_dmr_ch11, '0']
- [resamp_iq_dmr_ch12, '0', lpf_dmr_ch12, '0']
- [resamp_iq_dmr_ch13, '0', lpf_dmr_ch13, '0']
- [resamp_iq_dmr_ch14, '0', lpf_dmr_ch14, '0']
- [resamp_iq_dmr_ch15, '0', lpf_dmr_ch15, '0']
- [resamp_iq_dmr_ch2, '0', lpf_dmr_ch2, '0']
- [resamp_iq_dmr_ch3, '0', lpf_dmr_ch3, '0']
- [resamp_iq_dmr_ch4, '0', lpf_dmr_ch4, '0']
- [resamp_iq_dmr_ch5, '0', lpf_dmr_ch5, '0']
- [resamp_iq_dmr_ch6, '0', lpf_dmr_ch6, '0']
- [resamp_iq_dmr_ch7, '0', lpf_dmr_ch7, '0']
- [resamp_iq_dmr_ch8, '0', lpf_dmr_ch8, '0']
- [resamp_iq_dmr_ch9, '0', lpf_dmr_ch9, '0']
- [resamp_iq_nxdn_ch0, '0', lpf_nxdn_ch0, '0']
- [resamp_iq_nxdn_ch1, '0', lpf_nxdn_ch1, '0']
- [resamp_iq_nxdn_ch10, '0', lpf_nxdn_ch10, '0']
- [resamp_iq_nxdn_ch11, '0', lpf_nxdn_ch11, '0']
- [resamp_iq_nxdn_ch12, '0', lpf_nxdn_ch12, '0']
- [resamp_iq_nxdn_ch13, '0', lpf_nxdn_ch13, '0']
- [resamp_iq_nxdn_ch14, '0', lpf_nxdn_ch14, '0']
- [resamp_iq_nxdn_ch15, '0', lpf_nxdn_ch15, '0']
- [resamp_iq_nxdn_ch2, '0', lpf_nxdn_ch2, '0']
- [resamp_iq_nxdn_ch3, '0', lpf_nxdn_ch3, '0']
- [resamp_iq_nxdn_ch4, '0', lpf_nxdn_ch4, '0']
- [resamp_iq_nxdn_ch5, '0', lpf_nxdn_ch5, '0']
- [resamp_iq_nxdn_ch6, '0', lpf_nxdn_ch6, '0']
- [resamp_iq_nxdn_ch7, '0', lpf_nxdn_ch7, '0']
- [resamp_iq_nxdn_ch8, '0', lpf_nxdn_ch8, '0']
- [resamp_iq_nxdn_ch9, '0', lpf_nxdn_ch9, '0']
- [resamp_iq_p25_ch0, '0', lpf_p25_ch0, '0']
- [resamp_iq_p25_ch1, '0', lpf_p25_ch1, '0']
- [resamp_iq_p25_ch2, '0', lpf_p25_ch2, '0']
- [resamp_iq_p25_ch3, '0', lpf_p25_ch3, '0']
- [resamp_iq_p25_ch4, '0', lpf_p25_ch4, '0']
- [resamp_iq_p25_ch5, '0', lpf_p25_ch5, '0']
- [resamp_iq_p25_ch6, '0', lpf_p25_ch6, '0']
- [resamp_iq_p25_ch7, '0', lpf_p25_ch7, '0']
- [resamp_iq_p25_ch8, '0', lpf_p25_ch8, '0']
- [resamp_iq_p25_ch9, '0', lpf_p25_ch9, '0']
- [squelch_dmr_ch0, '0', demod_dmr_ch0, '0']
- [squelch_dmr_ch1, '0', demod_dmr_ch1, '0']
- [squelch_dmr_ch10, '0', demod_dmr_ch10, '0']
- [squelch_dmr_ch11, '0', demod_dmr_ch11, '0']
- [squelch_dmr_ch12, '0', demod_dmr_ch12, '0']
- [squelch_dmr_ch13, '0', demod_dmr_ch13, '0']
- [squelch_dmr_ch14, '0', demod_dmr_ch14, '0']
- [squelch_dmr_ch15, '0', demod_dmr_ch15, '0']
- [squelch_dmr_ch2, '0', demod_dmr_ch2, '0']
- [squelch_dmr_ch3, '0', demod_dmr_ch3, '0']
- [squelch_dmr_ch4, '0', demod_dmr_ch4, '0']
- [squelch_dmr_ch5, '0', demod_dmr_ch5, '0']
- [squelch_dmr_ch6, '0', demod_dmr_ch6, '0']
- [squelch_dmr_ch7, '0', demod_dmr_ch7, '0']
- [squelch_dmr_ch8, '0', demod_dmr_ch8, '0']
- [squelch_dmr_ch9, '0', demod_dmr_ch9, '0']
- [squelch_nxdn_ch0, '0', demod_nxdn_ch0, '0']
- [squelch_nxdn_ch1, '0', demod_nxdn_ch1, '0']
- [squelch_nxdn_ch10, '0', demod_nxdn_ch10, '0']
- [squelch_nxdn_ch11, '0', demod_nxdn_ch11, '0']
- [squelch_nxdn_ch12, '0', demod_nxdn_ch12, '0']
- [squelch_nxdn_ch13, '0', demod_nxdn_ch13, '0']
- [squelch_nxdn_ch14, '0', demod_nxdn_ch14, '0']
- [squelch_nxdn_ch15, '0', demod_nxdn_ch15, '0']
- [squelch_nxdn_ch2, '0', demod_nxdn_ch2, '0']
- [squelch_nxdn_ch3, '0', demod_nxdn_ch3, '0']
- [squelch_nxdn_ch4, '0', demod_nxdn_ch4, '0']
- [squelch_nxdn_ch5, '0', demod_nxdn_ch5, '0']
- [squelch_nxdn_ch6, '0', demod_nxdn_ch6, '0']
- [squelch_nxdn_ch7, '0', demod_nxdn_ch7, '0']
- [squelch_nxdn_ch8, '0', demod_nxdn_ch8, '0']
- [squelch_nxdn_ch9, '0', demod_nxdn_ch9, '0']
- [squelch_p25_ch0, '0', demod_p25_ch0, '0']
- [squelch_p25_ch1, '0', demod_p25_ch1, '0']
- [squelch_p25_ch2, '0', demod_p25_ch2, '0']
- [squelch_p25_ch3, '0', demod_p25_ch3, '0']
- [squelch_p25_ch4, '0', demod_p25_ch4, '0']
- [squelch_p25_ch5, '0', demod_p25_ch5, '0']
- [squelch_p25_ch6, '0', demod_p25_ch6, '0']
- [squelch_p25_ch7, '0', demod_p25_ch7, '0']
- [squelch_p25_ch8, '0', demod_p25_ch8, '0']
- [squelch_p25_ch9, '0', demod_p25_ch9, '0']
- [tetra_decoder_block_0, '0', audio_mix_tetra, '0']
- [tetra_decoder_block_0, '0', audio_sink_tn1, '0']
- [tetra_decoder_block_0, '1', audio_mix_tetra, '1']
- [tetra_decoder_block_0, '1', audio_sink_tn2, '0']
- [tetra_decoder_block_0, '2', audio_mix_tetra, '2']
- [tetra_decoder_block_0, '2', audio_sink_tn3, '0']
- [tetra_decoder_block_0, '3', audio_mix_tetra, '3']
- [tetra_decoder_block_0, '3', audio_sink_tn4, '0']
- [tetra_decoder_block_0, call_log, blocks_message_debug_0, print]
- [tetra_decoder_block_0, call_log, bridge_zmq_tetra_events, in]
- [vol_dmr_ch0, '0', audio_mix_dmr, '0']
- [vol_dmr_ch1, '0', audio_mix_dmr, '1']
- [vol_dmr_ch10, '0', audio_mix_dmr, '10']
- [vol_dmr_ch11, '0', audio_mix_dmr, '11']
- [vol_dmr_ch12, '0', audio_mix_dmr, '12']
- [vol_dmr_ch13, '0', audio_mix_dmr, '13']
- [vol_dmr_ch14, '0', audio_mix_dmr, '14']
- [vol_dmr_ch15, '0', audio_mix_dmr, '15']
- [vol_dmr_ch2, '0', audio_mix_dmr, '2']
- [vol_dmr_ch3, '0', audio_mix_dmr, '3']
- [vol_dmr_ch4, '0', audio_mix_dmr, '4']
- [vol_dmr_ch5, '0', audio_mix_dmr, '5']
- [vol_dmr_ch6, '0', audio_mix_dmr, '6']
- [vol_dmr_ch7, '0', audio_mix_dmr, '7']
- [vol_dmr_ch8, '0', audio_mix_dmr, '8']
- [vol_dmr_ch9, '0', audio_mix_dmr, '9']
- [vol_nxdn_ch0, '0', audio_mix_nxdn, '0']
- [vol_nxdn_ch1, '0', audio_mix_nxdn, '1']
- [vol_nxdn_ch10, '0', audio_mix_nxdn, '10']
- [vol_nxdn_ch11, '0', audio_mix_nxdn, '11']
- [vol_nxdn_ch12, '0', audio_mix_nxdn, '12']
- [vol_nxdn_ch13, '0', audio_mix_nxdn, '13']
- [vol_nxdn_ch14, '0', audio_mix_nxdn, '14']
- [vol_nxdn_ch15, '0', audio_mix_nxdn, '15']
- [vol_nxdn_ch2, '0', audio_mix_nxdn, '2']
- [vol_nxdn_ch3, '0', audio_mix_nxdn, '3']
- [vol_nxdn_ch4, '0', audio_mix_nxdn, '4']
- [vol_nxdn_ch5, '0', audio_mix_nxdn, '5']
- [vol_nxdn_ch6, '0', audio_mix_nxdn, '6']
- [vol_nxdn_ch7, '0', audio_mix_nxdn, '7']
- [vol_nxdn_ch8, '0', audio_mix_nxdn, '8']
- [vol_nxdn_ch9, '0', audio_mix_nxdn, '9']
- [vol_p25_ch0, '0', audio_mix_p25, '0']
- [vol_p25_ch1, '0', audio_mix_p25, '1']
- [vol_p25_ch2, '0', audio_mix_p25, '2']
- [vol_p25_ch3, '0', audio_mix_p25, '3']
- [vol_p25_ch4, '0', audio_mix_p25, '4']
- [vol_p25_ch5, '0', audio_mix_p25, '5']
- [vol_p25_ch6, '0', audio_mix_p25, '6']
- [vol_p25_ch7, '0', audio_mix_p25, '7']
- [vol_p25_ch8, '0', audio_mix_p25, '8']
- [vol_p25_ch9, '0', audio_mix_p25, '9']

metadata:
  file_format: 1
