options:
  parameters:
    author: AVGARDE SYSTEMS — SecureCOM M1
    description: Module 2 — 42-Channel Decoder with Combined Spectrum Analyzer
    generate_options: qt_gui
    id: securecom_module2_decoder
    output_language: python
    title: SecureCOM Module 2 — Multiband Real-Time Receiver
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: '36000'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[1-1j, 1+1j, -1-1j, 1-1j]'
    precision: '8'
    soft_dec_lut: '''auto'''
    type: dqpsk
  states: {}
- name: decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: freq_offset_khz
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,1]'
    label: Baseband offset [kHz]
    type: real
    value: '-1.714'
  states: {}
- name: frequency_mhz
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,0]'
    label: Frequency [MHz]
    type: real
    value: '467.5625'
  states: {}
- name: gain_demod
  id: variable_qtgui_range
  parameters:
    comment: DMR FM demod gain 1.0 -- measured optimum, offline decode test on real captured IQ (3.93 gave silence)
    label: FM Demod Gain (DMR)
    start: '0.05'
    step: '0.01'
    stop: '10.0'
    value: '1.0'
  states: {}
- name: gain_demod_nxdn
  id: variable_qtgui_range
  parameters:
    comment: NXDN96 gain = 48k/(2pi*1050Hz) = 7.28 (deviation to verify on air)
    label: FM Demod Gain (NXDN)
    start: '0.05'
    step: '0.01'
    stop: '14.0'
    value: '1.0'
  states: {}
- name: gain_demod_p25
  id: variable_qtgui_range
  parameters:
    comment: P25 C4FM gain = 48k/(2pi*1800Hz) = 4.24
    label: FM Demod Gain (P25)
    start: '0.05'
    step: '0.01'
    stop: '10.0'
    value: '1.0'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: ppm_corr
  id: variable_qtgui_range
  parameters:
    gui_hint: '[2,0,1,2]'
    label: PPM correction
    rangeType: int
    start: '-20'
    step: '1'
    stop: '15'
    value: '0'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 'TCP IQ from Module 1: 200 kSps'
    value: '200000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: constel
    modulus: '1'
    step_size: '10e-3'
    type: cma
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '8'
    reference: '1'
  states: {}
- name: aresamp_dmr
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch0 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_nxdn
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch0 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: aresamp_p25
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch0 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: audio_mix_tetra
  id: blocks_add_xx
  parameters:
    comment: TETRA 4-timeslot combined audio (for convenience listening)
    maxoutbuf: '1024'
    num_inputs: '4'
    type: float
  states: {}
- name: audio_sink_tetra_combined
  id: audio_sink
  parameters:
    comment: TETRA combined (all 4 slots mixed)
    samp_rate: '8000'
  states: {}
- name: audio_sink_tn1
  id: audio_sink
  parameters:
    comment: Timeslot 1
    samp_rate: '8000'
  states: {}
- name: audio_sink_tn2
  id: audio_sink
  parameters:
    comment: Timeslot 2
    samp_rate: '8000'
  states: {}
- name: audio_sink_tn3
  id: audio_sink
  parameters:
    comment: Timeslot 3
    samp_rate: '8000'
  states: {}
- name: audio_sink_tn4
  id: audio_sink
  parameters:
    comment: Timeslot 4
    samp_rate: '8000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: TETRA call log
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constel.bits_per_symbol()
  states: {}
- name: bridge_zmq_dmr
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:9101
    comment: 'bridge tap: real DMR combined audio @48k'
    timeout: '100'
    type: float
  states: {}
- name: bridge_zmq_nxdn
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:9102
    comment: 'bridge tap: real NXDN combined audio @48k'
    timeout: '100'
    type: float
  states: {}
- name: bridge_zmq_p25
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:9103
    comment: 'bridge tap: real P25 combined audio @48k'
    timeout: '100'
    type: float
  states: {}
- name: bridge_zmq_tetra
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:9104
    comment: 'bridge tap: real TETRA combined audio @8k'
    timeout: '100'
    type: float
  states: {}
- name: bridge_zmq_tetra_events
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:9105
    comment: 'bridge tap: real TETRA call_log events'
    timeout: '100'
  states: {}
- name: demod_dmr
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch0 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {}
- name: demod_nxdn
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch0 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn
    maxoutbuf: '1024'
  states: {}
- name: demod_p25
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch0 FM Demodulator (gain=0.2)
    gain: gain_demod_p25
    maxoutbuf: '1024'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters: {}
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '45'
    rolloff: '0.35'
    samps_per_sym: sps
    type: cc
    w: '0.03141592653589793'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: sps
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: constel.pre_diff_code()
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.06283185307179586'
    max_dev: '1.5'
    osps: sps
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: dsd_dmr
  id: dsd_block_ff
  parameters:
    comment: DMR ch0 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_nxdn
  id: dsd_block_ff
  parameters:
    comment: NXDN ch0 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: dsd_p25
  id: dsd_block_ff
  parameters:
    comment: P25 ch0 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset_khz*1e3
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,12500,12500*0.2)
    type: ccc
  states: {}
- name: lpf_dmr
  id: low_pass_filter
  parameters:
    comment: DMR ch0 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_nxdn
  id: low_pass_filter
  parameters:
    comment: NXDN ch0 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_p25
  id: low_pass_filter
  parameters:
    comment: P25 ch0 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(samp_rate)/(float(decim)*float(channel_rate))
    type: complex
  states: {}
- name: network_tcp_source_dmr
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: TCP 127.0.0.1:7001 — DMR446 446.09375MHz
    maxoutbuf: '1024'
    port: '7001'
    server: 'False'
    type: complex
  states: {}
- name: network_tcp_source_nxdn
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: TCP 127.0.0.1:7002 — NXDN96 451.09375MHz
    maxoutbuf: '1024'
    port: '7002'
    server: 'False'
    type: complex
  states: {}
- name: network_tcp_source_p25
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: TCP 127.0.0.1:7003 — P25 Phase 1 450.09375MHz
    maxoutbuf: '1024'
    port: '7003'
    server: 'False'
    type: complex
  states: {}
- name: network_tcp_source_tetra
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: TCP 127.0.0.1:7004 — TETRA 420.0MHz
    maxoutbuf: '1024'
    port: '7004'
    server: 'False'
    type: complex
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    comment: DMR446 16ch @ 12.5kSps/ch
    maxoutbuf: '1024'
    nchans: '16'
    osr: '1.0'
    taps: firdes.low_pass(16.0, samp_rate, (samp_rate/16.0)/2.0, 1000)
  states: {}
- name: pfb_channelizer_ccf_0_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    comment: P25 Phase 1 10ch @ 20kSps/ch
    maxoutbuf: '1024'
    nchans: '10'
    osr: '1.0'
    taps: firdes.low_pass(10.0, samp_rate, (samp_rate/10.0)/2.0, 1000)
  states: {}
- name: pfb_channelizer_ccf_0_1
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    comment: NXDN96 16ch @ 12.5kSps/ch
    maxoutbuf: '1024'
    nchans: '16'
    osr: '1.0'
    taps: firdes.low_pass(16.0, samp_rate, (samp_rate/16.0)/2.0, 1000)
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: '[4,0,1,2]'
    label1: Data 0
    legend: 'False'
    name: output
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_combined
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: samp_rate
    color5: '"magenta"'
    color6: '"cyan"'
    color7: '"dark red"'
    color8: '"dark blue"'
    comment: Combined Spectrum Analyzer for All 3 Bands
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label: Power Spectrum Density
    label1: DMR446 (7001)
    label2: NXDN96 (7002)
    label3: P25 Ph1 (7003)
    label4: TETRA (7004)
    label5: NXDN48 (7005)
    label6: D-STAR (7006)
    label7: X2-TDMA (7007)
    label8: ProVoice (7008)
    name: SecureCOM Live Spectrum — 8 bands (colours match the console)
    nconnections: '8'
    tr_tag: ''
    type: complex
    width1: '2'
    width2: '2'
    width3: '2'
  states: {}
- name: qtgui_time_sink_dnp
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color4: magenta
    color6: dark red
    color7: dark blue
    label1: DMR446
    label2: NXDN96
    label3: P25 Ph1
    label4: NXDN48
    label5: D-STAR
    label6: X2-TDMA
    label7: ProVoice
    name: Decoded Audio — 7 DSD protocols (48 kHz)
    nconnections: '7'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: qtgui_time_sink_tetra
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: audio
    name: Audio Time Domain — TETRA
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: channel_rate
    fc: '0'
    fftsize: '256'
    gui_hint: '[3,0,1,2]'
    label1: Data 0
    type: complex
    update_time: '0.1'
  states: {}
- name: resamp_iq_dmr
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch0: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_nxdn
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch0: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: resamp_iq_p25
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch0: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: squelch_dmr
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch0 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh_dmr
  states: {}
- name: squelch_nxdn
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch0 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh_nxdn
  states: {}
- name: squelch_p25
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch0 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh_p25
  states: {}
- name: tetra_decoder_block_0
  id: tetra_decoder_block
  parameters:
    comment: in-flowgraph tetra-kit + ACELP decode, no external process
    debug: 'True'
    log_level: '1'
    remove_fill_bits: 'True'
    wireshark_output: 'False'
  states: {}
- name: vol_dmr
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch0 Volume Boost
    const: volume_dmr
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_nxdn
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch0 Volume Boost
    const: volume_nxdn
    maxoutbuf: '1024'
    type: float
  states: {}
- name: vol_p25
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch0 Volume Boost
    const: volume_p25
    maxoutbuf: '1024'
    type: float
  states: {}
- name: iq_sum_dmr
  id: blocks_add_xx
  parameters:
    comment: DMR446 16-ch audio mixer @ 48kSps
    maxoutbuf: '1024'
    num_inputs: '16'
    type: complex
  states: {}
- name: squelch_thresh_dmr
  id: variable_qtgui_range
  parameters:
    comment: Channel Squelch Threshold (dB) — mutes idle channels
    label: Squelch DMR (dB)
    start: '-90'
    step: '1'
    stop: '-10'
    value: '-73'
  states: {}
- name: volume_dmr
  id: variable_qtgui_range
  parameters:
    comment: Audio Speech Output Volume
    label: Volume DMR
    start: '0.01'
    step: '0.01'
    stop: '20.0'
    value: '0.2'
  states: {}
- name: iq_sum_nxdn
  id: blocks_add_xx
  parameters:
    comment: DMR446 16-ch audio mixer @ 48kSps
    maxoutbuf: '1024'
    num_inputs: '16'
    type: complex
  states: {}
- name: squelch_thresh_nxdn
  id: variable_qtgui_range
  parameters:
    comment: Channel Squelch Threshold (dB) — mutes idle channels
    label: Squelch NXDN (dB)
    start: '-90'
    step: '1'
    stop: '-10'
    value: '-73'
  states: {}
- name: volume_nxdn
  id: variable_qtgui_range
  parameters:
    comment: Audio Speech Output Volume
    label: Volume NXDN
    start: '0.01'
    step: '0.01'
    stop: '20.0'
    value: '0.5'
  states: {}
- name: iq_sum_p25
  id: blocks_add_xx
  parameters:
    comment: DMR446 16-ch audio mixer @ 48kSps
    maxoutbuf: '1024'
    num_inputs: '10'
    type: complex
  states: {}
- name: squelch_thresh_p25
  id: variable_qtgui_range
  parameters:
    comment: Channel Squelch Threshold (dB) — mutes idle channels
    label: Squelch P25 (dB)
    start: '-90'
    step: '1'
    stop: '-10'
    value: '-73'
  states: {}
- name: volume_p25
  id: variable_qtgui_range
  parameters:
    comment: Audio Speech Output Volume
    label: Volume P25
    start: '0.01'
    step: '0.01'
    stop: '20.0'
    value: '0.5'
  states: {}
- name: audio_sink_dmr
  id: audio_sink
  parameters:
    comment: PulseAudio System Default Audio Sink
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: audio_sink_nxdn
  id: audio_sink
  parameters:
    comment: PulseAudio System Default Audio Sink
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: audio_sink_p25
  id: audio_sink
  parameters:
    comment: PulseAudio System Default Audio Sink
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: network_tcp_source_nxdn48
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: TCP 127.0.0.1:7001 — DMR446 446.09375MHz
    maxoutbuf: '1024'
    port: '7005'
    server: 'False'
    type: complex
  states: {}
- name: pfb_channelizer_nxdn48
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    comment: DMR446 16ch @ 12.5kSps/ch
    maxoutbuf: '1024'
    nchans: '32'
    osr: '1.0'
    taps: firdes.low_pass(32.0, samp_rate, (samp_rate/32.0)/2.0, 1000)
  states: {}
- name: iq_sum_nxdn48
  id: blocks_add_xx
  parameters:
    comment: DMR446 16-ch audio mixer @ 48kSps
    maxoutbuf: '1024'
    num_inputs: '32'
    type: complex
  states: {}
- name: resamp_iq_nxdn48
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch0: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '192'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: lpf_nxdn48
  id: low_pass_filter
  parameters:
    comment: DMR ch0 Channel LPF
    cutoff_freq: '3000'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: squelch_nxdn48
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch0 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh_nxdn48
  states: {}
- name: demod_nxdn48
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch0 FM Demodulator (gain=0.2)
    gain: gain_demod_nxdn48
    maxoutbuf: '1024'
  states: {}
- name: dsd_nxdn48
  id: dsd_block_ff
  parameters:
    comment: DMR ch0 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN48_IDAS
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: aresamp_nxdn48
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch0 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: vol_nxdn48
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch0 Volume Boost
    const: volume_nxdn48
    maxoutbuf: '1024'
    type: float
  states: {}
- name: bridge_zmq_nxdn48
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:9106
    comment: 'bridge tap: real DMR combined audio @48k'
    timeout: '100'
    type: float
  states: {}
- name: audio_sink_nxdn48
  id: audio_sink
  parameters:
    comment: PulseAudio System Default Audio Sink
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: squelch_thresh_nxdn48
  id: variable_qtgui_range
  parameters:
    comment: Channel Squelch Threshold (dB) — mutes idle channels
    label: Squelch NXDN48 (dB)
    start: '-90'
    step: '1'
    stop: '-10'
    value: '-73'
  states: {}
- name: volume_nxdn48
  id: variable_qtgui_range
  parameters:
    comment: Audio Speech Output Volume
    label: Volume NXDN48
    start: '0.01'
    step: '0.01'
    stop: '20.0'
    value: '3.0'
  states: {}
- name: gain_demod_nxdn48
  id: variable_qtgui_range
  parameters:
    comment: DMR FM demod gain 1.0 -- measured optimum, offline decode test on real captured IQ (3.93 gave silence)
    label: FM Demod Gain (NXDN48)
    start: '0.05'
    step: '0.01'
    stop: '10.0'
    value: '1.0'
  states: {}
- name: network_tcp_source_dstar
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: TCP 127.0.0.1:7001 — DMR446 446.09375MHz
    maxoutbuf: '1024'
    port: '7006'
    server: 'False'
    type: complex
  states: {}
- name: pfb_channelizer_dstar
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    comment: DMR446 16ch @ 12.5kSps/ch
    maxoutbuf: '1024'
    nchans: '16'
    osr: '1.0'
    taps: firdes.low_pass(16.0, samp_rate, (samp_rate/16.0)/2.0, 1000)
  states: {}
- name: iq_sum_dstar
  id: blocks_add_xx
  parameters:
    comment: DMR446 16-ch audio mixer @ 48kSps
    maxoutbuf: '1024'
    num_inputs: '16'
    type: complex
  states: {}
- name: resamp_iq_dstar
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch0: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: lpf_dstar
  id: low_pass_filter
  parameters:
    comment: DMR ch0 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: squelch_dstar
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch0 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh_dstar
  states: {}
- name: demod_dstar
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch0 FM Demodulator (gain=0.2)
    gain: gain_demod_dstar
    maxoutbuf: '1024'
  states: {}
- name: dsd_dstar
  id: dsd_block_ff
  parameters:
    comment: DMR ch0 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DSTAR
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: aresamp_dstar
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch0 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: vol_dstar
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch0 Volume Boost
    const: volume_dstar
    maxoutbuf: '1024'
    type: float
  states: {}
- name: bridge_zmq_dstar
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:9107
    comment: 'bridge tap: real DMR combined audio @48k'
    timeout: '100'
    type: float
  states: {}
- name: audio_sink_dstar
  id: audio_sink
  parameters:
    comment: PulseAudio System Default Audio Sink
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: squelch_thresh_dstar
  id: variable_qtgui_range
  parameters:
    comment: Channel Squelch Threshold (dB) — mutes idle channels
    label: Squelch D-STAR (dB)
    start: '-90'
    step: '1'
    stop: '-10'
    value: '-73'
  states: {}
- name: volume_dstar
  id: variable_qtgui_range
  parameters:
    comment: Audio Speech Output Volume
    label: Volume D-STAR
    start: '0.01'
    step: '0.01'
    stop: '20.0'
    value: '0.5'
  states: {}
- name: gain_demod_dstar
  id: variable_qtgui_range
  parameters:
    comment: DMR FM demod gain 1.0 -- measured optimum, offline decode test on real captured IQ (3.93 gave silence)
    label: FM Demod Gain (D-STAR)
    start: '0.05'
    step: '0.01'
    stop: '10.0'
    value: '1.0'
  states: {}
- name: network_tcp_source_x2tdma
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: TCP 127.0.0.1:7001 — DMR446 446.09375MHz
    maxoutbuf: '1024'
    port: '7007'
    server: 'False'
    type: complex
  states: {}
- name: pfb_channelizer_x2tdma
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    comment: DMR446 16ch @ 12.5kSps/ch
    maxoutbuf: '1024'
    nchans: '16'
    osr: '1.0'
    taps: firdes.low_pass(16.0, samp_rate, (samp_rate/16.0)/2.0, 1000)
  states: {}
- name: iq_sum_x2tdma
  id: blocks_add_xx
  parameters:
    comment: DMR446 16-ch audio mixer @ 48kSps
    maxoutbuf: '1024'
    num_inputs: '16'
    type: complex
  states: {}
- name: resamp_iq_x2tdma
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch0: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: lpf_x2tdma
  id: low_pass_filter
  parameters:
    comment: DMR ch0 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: squelch_x2tdma
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch0 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh_x2tdma
  states: {}
- name: demod_x2tdma
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch0 FM Demodulator (gain=0.2)
    gain: gain_demod_x2tdma
    maxoutbuf: '1024'
  states: {}
- name: dsd_x2tdma
  id: dsd_block_ff
  parameters:
    comment: DMR ch0 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_X2_TDMA
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: aresamp_x2tdma
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch0 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: vol_x2tdma
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch0 Volume Boost
    const: volume_x2tdma
    maxoutbuf: '1024'
    type: float
  states: {}
- name: bridge_zmq_x2tdma
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:9108
    comment: 'bridge tap: real DMR combined audio @48k'
    timeout: '100'
    type: float
  states: {}
- name: audio_sink_x2tdma
  id: audio_sink
  parameters:
    comment: PulseAudio System Default Audio Sink
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: squelch_thresh_x2tdma
  id: variable_qtgui_range
  parameters:
    comment: Channel Squelch Threshold (dB) — mutes idle channels
    label: Squelch X2-TDMA (dB)
    start: '-90'
    step: '1'
    stop: '-10'
    value: '-73'
  states: {}
- name: volume_x2tdma
  id: variable_qtgui_range
  parameters:
    comment: Audio Speech Output Volume
    label: Volume X2-TDMA
    start: '0.01'
    step: '0.01'
    stop: '20.0'
    value: '0.5'
  states: {}
- name: gain_demod_x2tdma
  id: variable_qtgui_range
  parameters:
    comment: DMR FM demod gain 1.0 -- measured optimum, offline decode test on real captured IQ (3.93 gave silence)
    label: FM Demod Gain (X2-TDMA)
    start: '0.05'
    step: '0.01'
    stop: '10.0'
    value: '1.0'
  states: {}
- name: network_tcp_source_provoice
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: TCP 127.0.0.1:7001 — DMR446 446.09375MHz
    maxoutbuf: '1024'
    port: '7008'
    server: 'False'
    type: complex
  states: {}
- name: pfb_channelizer_provoice
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    comment: DMR446 16ch @ 12.5kSps/ch
    maxoutbuf: '1024'
    nchans: '8'
    osr: '1.0'
    taps: firdes.low_pass(8.0, samp_rate, (samp_rate/8.0)/2.0, 1000)
  states: {}
- name: iq_sum_provoice
  id: blocks_add_xx
  parameters:
    comment: DMR446 16-ch audio mixer @ 48kSps
    maxoutbuf: '1024'
    num_inputs: '8'
    type: complex
  states: {}
- name: resamp_iq_provoice
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch0: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '48'
    maxoutbuf: '1024'
    type: ccf
  states: {}
- name: lpf_provoice
  id: low_pass_filter
  parameters:
    comment: DMR ch0 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: squelch_provoice
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch0 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh_provoice
  states: {}
- name: demod_provoice
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch0 FM Demodulator (gain=0.2)
    gain: gain_demod_provoice
    maxoutbuf: '1024'
  states: {}
- name: dsd_provoice
  id: dsd_block_ff
  parameters:
    comment: DMR ch0 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_PROVOICE
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {}
- name: aresamp_provoice
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch0 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {}
- name: vol_provoice
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch0 Volume Boost
    const: volume_provoice
    maxoutbuf: '1024'
    type: float
  states: {}
- name: bridge_zmq_provoice
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:9109
    comment: 'bridge tap: real DMR combined audio @48k'
    timeout: '100'
    type: float
  states: {}
- name: audio_sink_provoice
  id: audio_sink
  parameters:
    comment: PulseAudio System Default Audio Sink
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: squelch_thresh_provoice
  id: variable_qtgui_range
  parameters:
    comment: Channel Squelch Threshold (dB) — mutes idle channels
    label: Squelch ProVoice (dB)
    start: '-90'
    step: '1'
    stop: '-10'
    value: '-73'
  states: {}
- name: volume_provoice
  id: variable_qtgui_range
  parameters:
    comment: Audio Speech Output Volume
    label: Volume ProVoice
    start: '0.01'
    step: '0.01'
    stop: '20.0'
    value: '0.5'
  states: {}
- name: gain_demod_provoice
  id: variable_qtgui_range
  parameters:
    comment: DMR FM demod gain 1.0 -- measured optimum, offline decode test on real captured IQ (3.93 gave silence)
    label: FM Demod Gain (ProVoice)
    start: '0.05'
    step: '0.01'
    stop: '10.0'
    value: '1.0'
  states: {}

connections:
- [analog_feedforward_agc_cc_0, '0', digital_fll_band_edge_cc_0, '0']
- [aresamp_dmr, '0', vol_dmr, '0']
- [aresamp_nxdn, '0', vol_nxdn, '0']
- [aresamp_p25, '0', vol_p25, '0']
- [audio_mix_tetra, '0', audio_sink_tetra_combined, '0']
- [audio_mix_tetra, '0', bridge_zmq_tetra, '0']
- [audio_mix_tetra, '0', qtgui_time_sink_tetra, '0']
- [blocks_unpack_k_bits_bb_0, '0', tetra_decoder_block_0, '0']
- [demod_dmr, '0', dsd_dmr, '0']
- [demod_nxdn, '0', dsd_nxdn, '0']
- [demod_p25, '0', dsd_p25, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_diff_phasor_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_diff_phasor_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_linear_equalizer_0, '0', digital_diff_phasor_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [dsd_dmr, '0', aresamp_dmr, '0']
- [dsd_nxdn, '0', aresamp_nxdn, '0']
- [dsd_p25, '0', aresamp_p25, '0']
- [freq_xlating_fir_filter_xxx_0, '0', mmse_resampler_xx_0, '0']
- [lpf_dmr, '0', squelch_dmr, '0']
- [lpf_nxdn, '0', squelch_nxdn, '0']
- [lpf_p25, '0', squelch_p25, '0']
- [mmse_resampler_xx_0, '0', analog_feedforward_agc_cc_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [network_tcp_source_dmr, '0', pfb_channelizer_ccf_0, '0']
- [network_tcp_source_nxdn, '0', pfb_channelizer_ccf_0_1, '0']
- [network_tcp_source_p25, '0', pfb_channelizer_ccf_0_0, '0']
- [network_tcp_source_tetra, '0', freq_xlating_fir_filter_xxx_0, '0']
- [resamp_iq_dmr, '0', lpf_dmr, '0']
- [resamp_iq_nxdn, '0', lpf_nxdn, '0']
- [resamp_iq_p25, '0', lpf_p25, '0']
- [squelch_dmr, '0', demod_dmr, '0']
- [squelch_nxdn, '0', demod_nxdn, '0']
- [squelch_p25, '0', demod_p25, '0']
- [tetra_decoder_block_0, '0', audio_mix_tetra, '0']
- [tetra_decoder_block_0, '0', audio_sink_tn1, '0']
- [tetra_decoder_block_0, '1', audio_mix_tetra, '1']
- [tetra_decoder_block_0, '1', audio_sink_tn2, '0']
- [tetra_decoder_block_0, '2', audio_mix_tetra, '2']
- [tetra_decoder_block_0, '2', audio_sink_tn3, '0']
- [tetra_decoder_block_0, '3', audio_mix_tetra, '3']
- [tetra_decoder_block_0, '3', audio_sink_tn4, '0']
- [tetra_decoder_block_0, call_log, blocks_message_debug_0, print]
- [tetra_decoder_block_0, call_log, bridge_zmq_tetra_events, in]
- [pfb_channelizer_ccf_0, '0', iq_sum_dmr, '0']
- [pfb_channelizer_ccf_0, '1', iq_sum_dmr, '1']
- [pfb_channelizer_ccf_0, '2', iq_sum_dmr, '2']
- [pfb_channelizer_ccf_0, '3', iq_sum_dmr, '3']
- [pfb_channelizer_ccf_0, '4', iq_sum_dmr, '4']
- [pfb_channelizer_ccf_0, '5', iq_sum_dmr, '5']
- [pfb_channelizer_ccf_0, '6', iq_sum_dmr, '6']
- [pfb_channelizer_ccf_0, '7', iq_sum_dmr, '7']
- [pfb_channelizer_ccf_0, '8', iq_sum_dmr, '8']
- [pfb_channelizer_ccf_0, '9', iq_sum_dmr, '9']
- [pfb_channelizer_ccf_0, '10', iq_sum_dmr, '10']
- [pfb_channelizer_ccf_0, '11', iq_sum_dmr, '11']
- [pfb_channelizer_ccf_0, '12', iq_sum_dmr, '12']
- [pfb_channelizer_ccf_0, '13', iq_sum_dmr, '13']
- [pfb_channelizer_ccf_0, '14', iq_sum_dmr, '14']
- [pfb_channelizer_ccf_0, '15', iq_sum_dmr, '15']
- [iq_sum_dmr, '0', resamp_iq_dmr, '0']
- [vol_dmr, '0', bridge_zmq_dmr, '0']
- [pfb_channelizer_ccf_0_1, '0', iq_sum_nxdn, '0']
- [pfb_channelizer_ccf_0_1, '1', iq_sum_nxdn, '1']
- [pfb_channelizer_ccf_0_1, '2', iq_sum_nxdn, '2']
- [pfb_channelizer_ccf_0_1, '3', iq_sum_nxdn, '3']
- [pfb_channelizer_ccf_0_1, '4', iq_sum_nxdn, '4']
- [pfb_channelizer_ccf_0_1, '5', iq_sum_nxdn, '5']
- [pfb_channelizer_ccf_0_1, '6', iq_sum_nxdn, '6']
- [pfb_channelizer_ccf_0_1, '7', iq_sum_nxdn, '7']
- [pfb_channelizer_ccf_0_1, '8', iq_sum_nxdn, '8']
- [pfb_channelizer_ccf_0_1, '9', iq_sum_nxdn, '9']
- [pfb_channelizer_ccf_0_1, '10', iq_sum_nxdn, '10']
- [pfb_channelizer_ccf_0_1, '11', iq_sum_nxdn, '11']
- [pfb_channelizer_ccf_0_1, '12', iq_sum_nxdn, '12']
- [pfb_channelizer_ccf_0_1, '13', iq_sum_nxdn, '13']
- [pfb_channelizer_ccf_0_1, '14', iq_sum_nxdn, '14']
- [pfb_channelizer_ccf_0_1, '15', iq_sum_nxdn, '15']
- [iq_sum_nxdn, '0', resamp_iq_nxdn, '0']
- [vol_nxdn, '0', bridge_zmq_nxdn, '0']
- [pfb_channelizer_ccf_0_0, '0', iq_sum_p25, '0']
- [pfb_channelizer_ccf_0_0, '1', iq_sum_p25, '1']
- [pfb_channelizer_ccf_0_0, '2', iq_sum_p25, '2']
- [pfb_channelizer_ccf_0_0, '3', iq_sum_p25, '3']
- [pfb_channelizer_ccf_0_0, '4', iq_sum_p25, '4']
- [pfb_channelizer_ccf_0_0, '5', iq_sum_p25, '5']
- [pfb_channelizer_ccf_0_0, '6', iq_sum_p25, '6']
- [pfb_channelizer_ccf_0_0, '7', iq_sum_p25, '7']
- [pfb_channelizer_ccf_0_0, '8', iq_sum_p25, '8']
- [pfb_channelizer_ccf_0_0, '9', iq_sum_p25, '9']
- [iq_sum_p25, '0', resamp_iq_p25, '0']
- [vol_p25, '0', bridge_zmq_p25, '0']
- [vol_dmr, '0', audio_sink_dmr, '0']
- [vol_nxdn, '0', audio_sink_nxdn, '0']
- [vol_p25, '0', audio_sink_p25, '0']
- [network_tcp_source_nxdn48, '0', pfb_channelizer_nxdn48, '0']
- [pfb_channelizer_nxdn48, '0', iq_sum_nxdn48, '0']
- [pfb_channelizer_nxdn48, '1', iq_sum_nxdn48, '1']
- [pfb_channelizer_nxdn48, '2', iq_sum_nxdn48, '2']
- [pfb_channelizer_nxdn48, '3', iq_sum_nxdn48, '3']
- [pfb_channelizer_nxdn48, '4', iq_sum_nxdn48, '4']
- [pfb_channelizer_nxdn48, '5', iq_sum_nxdn48, '5']
- [pfb_channelizer_nxdn48, '6', iq_sum_nxdn48, '6']
- [pfb_channelizer_nxdn48, '7', iq_sum_nxdn48, '7']
- [pfb_channelizer_nxdn48, '8', iq_sum_nxdn48, '8']
- [pfb_channelizer_nxdn48, '9', iq_sum_nxdn48, '9']
- [pfb_channelizer_nxdn48, '10', iq_sum_nxdn48, '10']
- [pfb_channelizer_nxdn48, '11', iq_sum_nxdn48, '11']
- [pfb_channelizer_nxdn48, '12', iq_sum_nxdn48, '12']
- [pfb_channelizer_nxdn48, '13', iq_sum_nxdn48, '13']
- [pfb_channelizer_nxdn48, '14', iq_sum_nxdn48, '14']
- [pfb_channelizer_nxdn48, '15', iq_sum_nxdn48, '15']
- [pfb_channelizer_nxdn48, '16', iq_sum_nxdn48, '16']
- [pfb_channelizer_nxdn48, '17', iq_sum_nxdn48, '17']
- [pfb_channelizer_nxdn48, '18', iq_sum_nxdn48, '18']
- [pfb_channelizer_nxdn48, '19', iq_sum_nxdn48, '19']
- [pfb_channelizer_nxdn48, '20', iq_sum_nxdn48, '20']
- [pfb_channelizer_nxdn48, '21', iq_sum_nxdn48, '21']
- [pfb_channelizer_nxdn48, '22', iq_sum_nxdn48, '22']
- [pfb_channelizer_nxdn48, '23', iq_sum_nxdn48, '23']
- [pfb_channelizer_nxdn48, '24', iq_sum_nxdn48, '24']
- [pfb_channelizer_nxdn48, '25', iq_sum_nxdn48, '25']
- [pfb_channelizer_nxdn48, '26', iq_sum_nxdn48, '26']
- [pfb_channelizer_nxdn48, '27', iq_sum_nxdn48, '27']
- [pfb_channelizer_nxdn48, '28', iq_sum_nxdn48, '28']
- [pfb_channelizer_nxdn48, '29', iq_sum_nxdn48, '29']
- [pfb_channelizer_nxdn48, '30', iq_sum_nxdn48, '30']
- [pfb_channelizer_nxdn48, '31', iq_sum_nxdn48, '31']
- [iq_sum_nxdn48, '0', resamp_iq_nxdn48, '0']
- [resamp_iq_nxdn48, '0', lpf_nxdn48, '0']
- [lpf_nxdn48, '0', squelch_nxdn48, '0']
- [squelch_nxdn48, '0', demod_nxdn48, '0']
- [demod_nxdn48, '0', dsd_nxdn48, '0']
- [dsd_nxdn48, '0', aresamp_nxdn48, '0']
- [aresamp_nxdn48, '0', vol_nxdn48, '0']
- [vol_nxdn48, '0', bridge_zmq_nxdn48, '0']
- [vol_nxdn48, '0', audio_sink_nxdn48, '0']
- [network_tcp_source_dstar, '0', pfb_channelizer_dstar, '0']
- [pfb_channelizer_dstar, '0', iq_sum_dstar, '0']
- [pfb_channelizer_dstar, '1', iq_sum_dstar, '1']
- [pfb_channelizer_dstar, '2', iq_sum_dstar, '2']
- [pfb_channelizer_dstar, '3', iq_sum_dstar, '3']
- [pfb_channelizer_dstar, '4', iq_sum_dstar, '4']
- [pfb_channelizer_dstar, '5', iq_sum_dstar, '5']
- [pfb_channelizer_dstar, '6', iq_sum_dstar, '6']
- [pfb_channelizer_dstar, '7', iq_sum_dstar, '7']
- [pfb_channelizer_dstar, '8', iq_sum_dstar, '8']
- [pfb_channelizer_dstar, '9', iq_sum_dstar, '9']
- [pfb_channelizer_dstar, '10', iq_sum_dstar, '10']
- [pfb_channelizer_dstar, '11', iq_sum_dstar, '11']
- [pfb_channelizer_dstar, '12', iq_sum_dstar, '12']
- [pfb_channelizer_dstar, '13', iq_sum_dstar, '13']
- [pfb_channelizer_dstar, '14', iq_sum_dstar, '14']
- [pfb_channelizer_dstar, '15', iq_sum_dstar, '15']
- [iq_sum_dstar, '0', resamp_iq_dstar, '0']
- [resamp_iq_dstar, '0', lpf_dstar, '0']
- [lpf_dstar, '0', squelch_dstar, '0']
- [squelch_dstar, '0', demod_dstar, '0']
- [demod_dstar, '0', dsd_dstar, '0']
- [dsd_dstar, '0', aresamp_dstar, '0']
- [aresamp_dstar, '0', vol_dstar, '0']
- [vol_dstar, '0', bridge_zmq_dstar, '0']
- [vol_dstar, '0', audio_sink_dstar, '0']
- [network_tcp_source_x2tdma, '0', pfb_channelizer_x2tdma, '0']
- [pfb_channelizer_x2tdma, '0', iq_sum_x2tdma, '0']
- [pfb_channelizer_x2tdma, '1', iq_sum_x2tdma, '1']
- [pfb_channelizer_x2tdma, '2', iq_sum_x2tdma, '2']
- [pfb_channelizer_x2tdma, '3', iq_sum_x2tdma, '3']
- [pfb_channelizer_x2tdma, '4', iq_sum_x2tdma, '4']
- [pfb_channelizer_x2tdma, '5', iq_sum_x2tdma, '5']
- [pfb_channelizer_x2tdma, '6', iq_sum_x2tdma, '6']
- [pfb_channelizer_x2tdma, '7', iq_sum_x2tdma, '7']
- [pfb_channelizer_x2tdma, '8', iq_sum_x2tdma, '8']
- [pfb_channelizer_x2tdma, '9', iq_sum_x2tdma, '9']
- [pfb_channelizer_x2tdma, '10', iq_sum_x2tdma, '10']
- [pfb_channelizer_x2tdma, '11', iq_sum_x2tdma, '11']
- [pfb_channelizer_x2tdma, '12', iq_sum_x2tdma, '12']
- [pfb_channelizer_x2tdma, '13', iq_sum_x2tdma, '13']
- [pfb_channelizer_x2tdma, '14', iq_sum_x2tdma, '14']
- [pfb_channelizer_x2tdma, '15', iq_sum_x2tdma, '15']
- [iq_sum_x2tdma, '0', resamp_iq_x2tdma, '0']
- [resamp_iq_x2tdma, '0', lpf_x2tdma, '0']
- [lpf_x2tdma, '0', squelch_x2tdma, '0']
- [squelch_x2tdma, '0', demod_x2tdma, '0']
- [demod_x2tdma, '0', dsd_x2tdma, '0']
- [dsd_x2tdma, '0', aresamp_x2tdma, '0']
- [aresamp_x2tdma, '0', vol_x2tdma, '0']
- [vol_x2tdma, '0', bridge_zmq_x2tdma, '0']
- [vol_x2tdma, '0', audio_sink_x2tdma, '0']
- [network_tcp_source_provoice, '0', pfb_channelizer_provoice, '0']
- [pfb_channelizer_provoice, '0', iq_sum_provoice, '0']
- [pfb_channelizer_provoice, '1', iq_sum_provoice, '1']
- [pfb_channelizer_provoice, '2', iq_sum_provoice, '2']
- [pfb_channelizer_provoice, '3', iq_sum_provoice, '3']
- [pfb_channelizer_provoice, '4', iq_sum_provoice, '4']
- [pfb_channelizer_provoice, '5', iq_sum_provoice, '5']
- [pfb_channelizer_provoice, '6', iq_sum_provoice, '6']
- [pfb_channelizer_provoice, '7', iq_sum_provoice, '7']
- [iq_sum_provoice, '0', resamp_iq_provoice, '0']
- [resamp_iq_provoice, '0', lpf_provoice, '0']
- [lpf_provoice, '0', squelch_provoice, '0']
- [squelch_provoice, '0', demod_provoice, '0']
- [demod_provoice, '0', dsd_provoice, '0']
- [dsd_provoice, '0', aresamp_provoice, '0']
- [aresamp_provoice, '0', vol_provoice, '0']
- [vol_provoice, '0', bridge_zmq_provoice, '0']
- [vol_provoice, '0', audio_sink_provoice, '0']
- [network_tcp_source_dmr, '0', qtgui_freq_sink_combined, '0']
- [network_tcp_source_nxdn, '0', qtgui_freq_sink_combined, '1']
- [network_tcp_source_p25, '0', qtgui_freq_sink_combined, '2']
- [network_tcp_source_tetra, '0', qtgui_freq_sink_combined, '3']
- [network_tcp_source_nxdn48, '0', qtgui_freq_sink_combined, '4']
- [network_tcp_source_dstar, '0', qtgui_freq_sink_combined, '5']
- [network_tcp_source_x2tdma, '0', qtgui_freq_sink_combined, '6']
- [network_tcp_source_provoice, '0', qtgui_freq_sink_combined, '7']
- [vol_dmr, '0', qtgui_time_sink_dnp, '0']
- [vol_nxdn, '0', qtgui_time_sink_dnp, '1']
- [vol_p25, '0', qtgui_time_sink_dnp, '2']
- [vol_nxdn48, '0', qtgui_time_sink_dnp, '3']
- [vol_dstar, '0', qtgui_time_sink_dnp, '4']
- [vol_x2tdma, '0', qtgui_time_sink_dnp, '5']
- [vol_provoice, '0', qtgui_time_sink_dnp, '6']

metadata:
  file_format: 1
