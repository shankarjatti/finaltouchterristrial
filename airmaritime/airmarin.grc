options:
  parameters:
    description: Air & Maritime Dual-Protocol Receiver (AIS on 9201, ADS-B on 9202)
    generate_options: qt_gui
    id: airmaritime_decoder
    output_language: python
    title: Air & Maritime Dual-Protocol Decoder (AIS, ADS-B)
  states: {}

blocks:
- name: fs
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: low_pass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '11000'
    gain: '1.0'
    samp_rate: samp_rate_0
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1152000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Detection Threshold
    type: real
    value: '0.010'
  states: {}
- name: adsb_decoder_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Brief"'
  states: {}
- name: adsb_demod_0
  id: adsb_demod
  parameters:
    fs: fs
  states: {}
- name: adsb_framer_1
  id: adsb_framer
  parameters:
    fs: fs
    threshold: threshold
  states: {}
- name: ais_invert_0
  id: ais_invert
  parameters: {}
  states: {}
- name: ais_invert_1
  id: ais_invert
  parameters: {}
  states: {}
- name: ais_pdu_to_nmea_0
  id: ais_pdu_to_nmea
  parameters:
    designator: '"A"'
  states: {}
- name: ais_pdu_to_nmea_1
  id: ais_pdu_to_nmea
  parameters:
    designator: '"B"'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: threshold
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: fs
    type: complex
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_0
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/shankar/Downloads/tutorials/sigtel_protocol_wav_folders/1_ADS-B/1_ADS-B_Synthetic_2.0MSps.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/shankar/Downloads/tutorials/delhi_testing/all_protocols_wav_samples/AIS_Marine/ais_b210_cable_capture_250k.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: ais_to_48k_0
  id: rational_resampler_xxx
  parameters:
    comment: '250k/5 = 50 kSps -> 48 kSps: exactly 5 samp/sym at 9600 baud'
    decim: '25'
    interp: '24'
    type: ccc
  states: {}
- name: ais_to_48k_1
  id: rational_resampler_xxx
  parameters:
    comment: '250k/5 = 50 kSps -> 48 kSps: exactly 5 samp/sym at 9600 baud'
    decim: '25'
    interp: '24'
    type: ccc
  states: {}
- name: ais_nrzi_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: 'AIS is NRZI: (x[n]-x[n-1])%2, then ais_invert'
    modulus: '2'
  states: {}
- name: ais_nrzi_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: 'AIS is NRZI: (x[n]-x[n-1])%2, then ais_invert'
    modulus: '2'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '5'
  states: {}
- name: digital_gmsk_demod_1
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '5'
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '64'
    min: '11'
  states: {}
- name: digital_hdlc_deframer_bp_1
  id: digital_hdlc_deframer_bp
  parameters:
    max: '64'
    min: '11'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-25000'
    decim: '5'
    samp_rate: samp_rate_0
    taps: low_pass_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '25000'
    decim: '5'
    samp_rate: samp_rate_0
    taps: low_pass_taps
    type: ccc
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: Demodulated Pulse
    label2: Threshold
    legend: 'False'
    marker1: '0'
    name: '"ADS-B Pulse Telemetry"'
    nconnections: '2'
    size: int(fs*150e-6)
    srate: int(fs)
    tr_delay: '1.25e-6'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    update_time: 1.0/100.0
    ymin: '0'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:9202
    comment: ADS-B decoded messages out
    timeout: '10'
  states: {}
- name: zeromq_pub_msg_sink_0_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:9201
    comment: AIS NMEA sentences out (Ch A + Ch B)
    timeout: '10'
  states: {}

connections:
- [adsb_decoder_0, decoded, zeromq_pub_msg_sink_0, in]
- [adsb_demod_0, '0', qtgui_time_sink_x_0, '0']
- [adsb_demod_0, demodulated, adsb_decoder_0, demodulated]
- [adsb_framer_1, '0', adsb_demod_0, '0']
- [ais_invert_0, '0', digital_hdlc_deframer_bp_0, '0']
- [ais_invert_1, '0', digital_hdlc_deframer_bp_1, '0']
- [ais_pdu_to_nmea_0, out, zeromq_pub_msg_sink_0_0, in]
- [ais_pdu_to_nmea_1, out, zeromq_pub_msg_sink_0_0, in]
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_squared_0, '0', adsb_framer_1, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_throttle_0_1, '0']
- [blocks_throttle_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle_0_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_0_1, '0', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_wavfile_source_0_0, '1', blocks_float_to_complex_0_0, '1']
- [ais_nrzi_0, '0', ais_invert_0, '0']
- [digital_gmsk_demod_0, '0', ais_nrzi_0, '0']
- [ais_nrzi_1, '0', ais_invert_1, '0']
- [digital_gmsk_demod_1, '0', ais_nrzi_1, '0']
- [digital_hdlc_deframer_bp_0, out, ais_pdu_to_nmea_0, print]
- [digital_hdlc_deframer_bp_1, out, ais_pdu_to_nmea_1, print]
- [ais_to_48k_0, '0', digital_gmsk_demod_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', ais_to_48k_0, '0']
- [ais_to_48k_1, '0', digital_gmsk_demod_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', ais_to_48k_1, '0']

metadata:
  file_format: 1
