options:
  parameters:
    author: AVGARDE SYSTEMS — SecureCOM M1
    description: Module 2 — High Performance 42-Channel Decoder
    generate_options: no_gui
    id: securecom_module2_decoder
    output_language: python
    title: SecureCOM Module 2 — Real-Time Decoder
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 'TCP IQ from Module 1: 200 kSps'
    value: '200000'
  states: {bus_structure: 'null'}
- name: squelch_thresh
  id: variable
  parameters:
    value: '-50'
  states: {bus_structure: 'null'}
- name: gain_demod
  id: variable
  parameters:
    value: '0.2'
  states: {bus_structure: 'null'}
- name: volume
  id: variable
  parameters:
    value: '3.0'
  states: {bus_structure: 'null'}
- name: network_tcp_source_dmr
  id: network_tcp_source
  parameters:
    comment: TCP 127.0.0.1:7001 — DMR446 446.09375MHz
    addr: 127.0.0.1
    port: '7001'
    server: 'False'
    type: complex
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: network_tcp_source_nxdn
  id: network_tcp_source
  parameters:
    comment: TCP 127.0.0.1:7002 — NXDN96 451.09375MHz
    addr: 127.0.0.1
    port: '7002'
    server: 'False'
    type: complex
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: network_tcp_source_p25
  id: network_tcp_source
  parameters:
    comment: TCP 127.0.0.1:7003 — P25 Phase 1 450.09375MHz
    addr: 127.0.0.1
    port: '7003'
    server: 'False'
    type: complex
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    comment: DMR446 16ch @ 12.5kSps/ch
    maxoutbuf: '1024'
    nchans: '16'
    osr: '1.0'
    taps: firdes.low_pass(16.0, samp_rate, (samp_rate/16.0)/2.0, 1000)
  states: {bus_structure: 'null'}
- name: pfb_channelizer_ccf_0_1
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    comment: NXDN96 16ch @ 12.5kSps/ch
    maxoutbuf: '1024'
    nchans: '16'
    osr: '1.0'
    taps: firdes.low_pass(16.0, samp_rate, (samp_rate/16.0)/2.0, 1000)
  states: {bus_structure: 'null'}
- name: pfb_channelizer_ccf_0_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    comment: P25 Phase 1 10ch @ 20kSps/ch
    maxoutbuf: '1024'
    nchans: '10'
    osr: '1.0'
    taps: firdes.low_pass(10.0, samp_rate, (samp_rate/10.0)/2.0, 1000)
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch0
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch0: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch0
  id: low_pass_filter
  parameters:
    comment: DMR ch0 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch0 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch0
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch0 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch0
  id: dsd_block_ff
  parameters:
    comment: DMR ch0 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch0
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch0 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch0
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch0 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch1
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch1: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch1
  id: low_pass_filter
  parameters:
    comment: DMR ch1 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch1 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch1
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch1 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch1
  id: dsd_block_ff
  parameters:
    comment: DMR ch1 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch1
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch1 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch1
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch1 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch2
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch2: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch2
  id: low_pass_filter
  parameters:
    comment: DMR ch2 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch2
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch2 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch2
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch2 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch2
  id: dsd_block_ff
  parameters:
    comment: DMR ch2 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch2
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch2 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch2
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch2 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch3
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch3: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch3
  id: low_pass_filter
  parameters:
    comment: DMR ch3 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch3
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch3 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch3
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch3 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch3
  id: dsd_block_ff
  parameters:
    comment: DMR ch3 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch3
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch3 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch3
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch3 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch4
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch4: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch4
  id: low_pass_filter
  parameters:
    comment: DMR ch4 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch4
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch4 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch4
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch4 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch4
  id: dsd_block_ff
  parameters:
    comment: DMR ch4 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch4
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch4 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch4
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch4 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch5
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch5: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch5
  id: low_pass_filter
  parameters:
    comment: DMR ch5 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch5
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch5 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch5
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch5 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch5
  id: dsd_block_ff
  parameters:
    comment: DMR ch5 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch5
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch5 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch5
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch5 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch6
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch6: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch6
  id: low_pass_filter
  parameters:
    comment: DMR ch6 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch6
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch6 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch6
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch6 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch6
  id: dsd_block_ff
  parameters:
    comment: DMR ch6 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch6
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch6 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch6
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch6 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch7
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch7: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch7
  id: low_pass_filter
  parameters:
    comment: DMR ch7 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch7
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch7 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch7
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch7 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch7
  id: dsd_block_ff
  parameters:
    comment: DMR ch7 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch7
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch7 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch7
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch7 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch8
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch8: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch8
  id: low_pass_filter
  parameters:
    comment: DMR ch8 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch8
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch8 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch8
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch8 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch8
  id: dsd_block_ff
  parameters:
    comment: DMR ch8 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch8
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch8 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch8
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch8 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch9
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch9: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch9
  id: low_pass_filter
  parameters:
    comment: DMR ch9 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch9
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch9 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch9
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch9 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch9
  id: dsd_block_ff
  parameters:
    comment: DMR ch9 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch9
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch9 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch9
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch9 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch10
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch10: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch10
  id: low_pass_filter
  parameters:
    comment: DMR ch10 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch10
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch10 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch10
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch10 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch10
  id: dsd_block_ff
  parameters:
    comment: DMR ch10 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch10
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch10 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch10
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch10 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch11
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch11: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch11
  id: low_pass_filter
  parameters:
    comment: DMR ch11 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch11
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch11 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch11
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch11 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch11
  id: dsd_block_ff
  parameters:
    comment: DMR ch11 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch11
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch11 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch11
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch11 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch12
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch12: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch12
  id: low_pass_filter
  parameters:
    comment: DMR ch12 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch12
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch12 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch12
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch12 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch12
  id: dsd_block_ff
  parameters:
    comment: DMR ch12 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch12
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch12 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch12
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch12 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch13
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch13: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch13
  id: low_pass_filter
  parameters:
    comment: DMR ch13 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch13
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch13 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch13
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch13 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch13
  id: dsd_block_ff
  parameters:
    comment: DMR ch13 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch13
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch13 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch13
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch13 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch14
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch14: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch14
  id: low_pass_filter
  parameters:
    comment: DMR ch14 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch14
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch14 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch14
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch14 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch14
  id: dsd_block_ff
  parameters:
    comment: DMR ch14 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch14
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch14 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch14
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch14 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_dmr_ch15
  id: rational_resampler_xxx
  parameters:
    comment: 'DMR ch15: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_dmr_ch15
  id: low_pass_filter
  parameters:
    comment: DMR ch15 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_dmr_ch15
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: DMR ch15 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_dmr_ch15
  id: analog_quadrature_demod_cf
  parameters:
    comment: DMR ch15 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_dmr_ch15
  id: dsd_block_ff
  parameters:
    comment: DMR ch15 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_DMR_MOTOTRBO
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_dmr_ch15
  id: rational_resampler_xxx
  parameters:
    comment: DMR ch15 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_dmr_ch15
  id: blocks_multiply_const_vxx
  parameters:
    comment: DMR ch15 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: audio_mix_dmr
  id: blocks_add_xx
  parameters:
    comment: DMR446 16-ch audio mixer @ 48kSps
    maxoutbuf: '1024'
    num_inputs: '16'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch0
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch0: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch0
  id: low_pass_filter
  parameters:
    comment: NXDN ch0 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch0 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch0
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch0 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch0
  id: dsd_block_ff
  parameters:
    comment: NXDN ch0 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch0
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch0 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch0
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch0 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch1
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch1: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch1
  id: low_pass_filter
  parameters:
    comment: NXDN ch1 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch1 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch1
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch1 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch1
  id: dsd_block_ff
  parameters:
    comment: NXDN ch1 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch1
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch1 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch1
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch1 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch2
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch2: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch2
  id: low_pass_filter
  parameters:
    comment: NXDN ch2 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch2
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch2 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch2
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch2 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch2
  id: dsd_block_ff
  parameters:
    comment: NXDN ch2 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch2
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch2 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch2
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch2 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch3
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch3: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch3
  id: low_pass_filter
  parameters:
    comment: NXDN ch3 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch3
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch3 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch3
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch3 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch3
  id: dsd_block_ff
  parameters:
    comment: NXDN ch3 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch3
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch3 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch3
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch3 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch4
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch4: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch4
  id: low_pass_filter
  parameters:
    comment: NXDN ch4 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch4
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch4 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch4
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch4 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch4
  id: dsd_block_ff
  parameters:
    comment: NXDN ch4 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch4
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch4 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch4
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch4 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch5
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch5: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch5
  id: low_pass_filter
  parameters:
    comment: NXDN ch5 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch5
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch5 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch5
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch5 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch5
  id: dsd_block_ff
  parameters:
    comment: NXDN ch5 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch5
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch5 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch5
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch5 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch6
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch6: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch6
  id: low_pass_filter
  parameters:
    comment: NXDN ch6 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch6
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch6 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch6
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch6 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch6
  id: dsd_block_ff
  parameters:
    comment: NXDN ch6 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch6
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch6 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch6
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch6 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch7
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch7: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch7
  id: low_pass_filter
  parameters:
    comment: NXDN ch7 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch7
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch7 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch7
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch7 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch7
  id: dsd_block_ff
  parameters:
    comment: NXDN ch7 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch7
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch7 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch7
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch7 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch8
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch8: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch8
  id: low_pass_filter
  parameters:
    comment: NXDN ch8 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch8
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch8 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch8
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch8 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch8
  id: dsd_block_ff
  parameters:
    comment: NXDN ch8 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch8
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch8 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch8
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch8 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch9
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch9: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch9
  id: low_pass_filter
  parameters:
    comment: NXDN ch9 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch9
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch9 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch9
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch9 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch9
  id: dsd_block_ff
  parameters:
    comment: NXDN ch9 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch9
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch9 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch9
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch9 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch10
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch10: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch10
  id: low_pass_filter
  parameters:
    comment: NXDN ch10 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch10
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch10 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch10
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch10 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch10
  id: dsd_block_ff
  parameters:
    comment: NXDN ch10 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch10
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch10 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch10
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch10 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch11
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch11: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch11
  id: low_pass_filter
  parameters:
    comment: NXDN ch11 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch11
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch11 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch11
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch11 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch11
  id: dsd_block_ff
  parameters:
    comment: NXDN ch11 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch11
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch11 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch11
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch11 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch12
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch12: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch12
  id: low_pass_filter
  parameters:
    comment: NXDN ch12 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch12
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch12 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch12
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch12 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch12
  id: dsd_block_ff
  parameters:
    comment: NXDN ch12 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch12
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch12 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch12
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch12 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch13
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch13: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch13
  id: low_pass_filter
  parameters:
    comment: NXDN ch13 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch13
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch13 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch13
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch13 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch13
  id: dsd_block_ff
  parameters:
    comment: NXDN ch13 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch13
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch13 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch13
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch13 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch14
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch14: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch14
  id: low_pass_filter
  parameters:
    comment: NXDN ch14 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch14
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch14 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch14
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch14 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch14
  id: dsd_block_ff
  parameters:
    comment: NXDN ch14 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch14
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch14 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch14
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch14 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_nxdn_ch15
  id: rational_resampler_xxx
  parameters:
    comment: 'NXDN ch15: PFB port -> 48 kHz IQ'
    decim: '25'
    fbw: '0.4'
    interp: '96'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_nxdn_ch15
  id: low_pass_filter
  parameters:
    comment: NXDN ch15 Channel LPF
    cutoff_freq: '6250'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_nxdn_ch15
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: NXDN ch15 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_nxdn_ch15
  id: analog_quadrature_demod_cf
  parameters:
    comment: NXDN ch15 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_nxdn_ch15
  id: dsd_block_ff
  parameters:
    comment: NXDN ch15 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_NXDN96
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_GFSK
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_nxdn_ch15
  id: rational_resampler_xxx
  parameters:
    comment: NXDN ch15 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_nxdn_ch15
  id: blocks_multiply_const_vxx
  parameters:
    comment: NXDN ch15 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: audio_mix_nxdn
  id: blocks_add_xx
  parameters:
    comment: NXDN96 16-ch audio mixer @ 48kSps
    maxoutbuf: '1024'
    num_inputs: '16'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_p25_ch0
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch0: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_p25_ch0
  id: low_pass_filter
  parameters:
    comment: P25 ch0 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_p25_ch0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch0 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_p25_ch0
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch0 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_p25_ch0
  id: dsd_block_ff
  parameters:
    comment: P25 ch0 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_p25_ch0
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch0 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_p25_ch0
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch0 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_p25_ch1
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch1: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_p25_ch1
  id: low_pass_filter
  parameters:
    comment: P25 ch1 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_p25_ch1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch1 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_p25_ch1
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch1 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_p25_ch1
  id: dsd_block_ff
  parameters:
    comment: P25 ch1 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_p25_ch1
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch1 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_p25_ch1
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch1 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_p25_ch2
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch2: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_p25_ch2
  id: low_pass_filter
  parameters:
    comment: P25 ch2 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_p25_ch2
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch2 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_p25_ch2
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch2 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_p25_ch2
  id: dsd_block_ff
  parameters:
    comment: P25 ch2 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_p25_ch2
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch2 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_p25_ch2
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch2 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_p25_ch3
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch3: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_p25_ch3
  id: low_pass_filter
  parameters:
    comment: P25 ch3 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_p25_ch3
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch3 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_p25_ch3
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch3 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_p25_ch3
  id: dsd_block_ff
  parameters:
    comment: P25 ch3 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_p25_ch3
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch3 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_p25_ch3
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch3 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_p25_ch4
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch4: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_p25_ch4
  id: low_pass_filter
  parameters:
    comment: P25 ch4 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_p25_ch4
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch4 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_p25_ch4
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch4 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_p25_ch4
  id: dsd_block_ff
  parameters:
    comment: P25 ch4 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_p25_ch4
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch4 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_p25_ch4
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch4 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_p25_ch5
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch5: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_p25_ch5
  id: low_pass_filter
  parameters:
    comment: P25 ch5 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_p25_ch5
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch5 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_p25_ch5
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch5 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_p25_ch5
  id: dsd_block_ff
  parameters:
    comment: P25 ch5 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_p25_ch5
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch5 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_p25_ch5
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch5 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_p25_ch6
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch6: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_p25_ch6
  id: low_pass_filter
  parameters:
    comment: P25 ch6 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_p25_ch6
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch6 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_p25_ch6
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch6 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_p25_ch6
  id: dsd_block_ff
  parameters:
    comment: P25 ch6 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_p25_ch6
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch6 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_p25_ch6
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch6 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_p25_ch7
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch7: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_p25_ch7
  id: low_pass_filter
  parameters:
    comment: P25 ch7 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_p25_ch7
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch7 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_p25_ch7
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch7 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_p25_ch7
  id: dsd_block_ff
  parameters:
    comment: P25 ch7 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_p25_ch7
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch7 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_p25_ch7
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch7 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_p25_ch8
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch8: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_p25_ch8
  id: low_pass_filter
  parameters:
    comment: P25 ch8 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_p25_ch8
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch8 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_p25_ch8
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch8 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_p25_ch8
  id: dsd_block_ff
  parameters:
    comment: P25 ch8 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_p25_ch8
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch8 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_p25_ch8
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch8 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: resamp_iq_p25_ch9
  id: rational_resampler_xxx
  parameters:
    comment: 'P25 ch9: PFB port -> 48 kHz IQ'
    decim: '5'
    fbw: '0.4'
    interp: '12'
    maxoutbuf: '1024'
    type: ccf
  states: {bus_structure: 'null'}
- name: lpf_p25_ch9
  id: low_pass_filter
  parameters:
    comment: P25 ch9 Channel LPF
    cutoff_freq: '9500'
    decim: '1'
    gain: '1.0'
    maxoutbuf: '1024'
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {bus_structure: 'null'}
- name: squelch_p25_ch9
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.05'
    comment: P25 ch9 Zero-Noise Channel Squelch Gate
    maxoutbuf: '1024'
    threshold: squelch_thresh
  states: {bus_structure: 'null'}
- name: demod_p25_ch9
  id: analog_quadrature_demod_cf
  parameters:
    comment: P25 ch9 FM Demodulator (gain=0.2)
    gain: gain_demod
    maxoutbuf: '1024'
  states: {bus_structure: 'null'}
- name: dsd_p25_ch9
  id: dsd_block_ff
  parameters:
    comment: P25 ch9 DSD Voice Decoder
    errorbars: 'True'
    frame: dsd.dsd_FRAME_P25_PHASE_1
    maxoutbuf: '1024'
    mod: dsd.dsd_MOD_C4FM
    uvquality: '3'
    verbosity: '0'
  states: {bus_structure: 'null'}
- name: aresamp_p25_ch9
  id: rational_resampler_xxx
  parameters:
    comment: P25 ch9 DSD Speech 8k -> 48k Audio
    decim: '1'
    fbw: '0.4'
    interp: '6'
    maxoutbuf: '1024'
    type: fff
  states: {bus_structure: 'null'}
- name: vol_p25_ch9
  id: blocks_multiply_const_vxx
  parameters:
    comment: P25 ch9 Volume Boost
    const: volume
    maxoutbuf: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: audio_mix_p25
  id: blocks_add_xx
  parameters:
    comment: P25 Phase 1 10-ch audio mixer @ 48kSps
    maxoutbuf: '1024'
    num_inputs: '10'
    type: float
  states: {bus_structure: 'null'}
- name: blocks_add_master
  id: blocks_add_xx
  parameters:
    comment: Master 3-band audio mixer @ 48kSps
    maxoutbuf: '1024'
    num_inputs: '3'
    type: float
  states: {bus_structure: 'null'}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: PulseAudio System Default Audio Sink
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {bus_structure: 'null'}

connections:
- [network_tcp_source_dmr, '0', pfb_channelizer_ccf_0, '0']
- [network_tcp_source_nxdn, '0', pfb_channelizer_ccf_0_1, '0']
- [network_tcp_source_p25, '0', pfb_channelizer_ccf_0_0, '0']
- [pfb_channelizer_ccf_0, '0', resamp_iq_dmr_ch0, '0']
- [resamp_iq_dmr_ch0, '0', lpf_dmr_ch0, '0']
- [lpf_dmr_ch0, '0', squelch_dmr_ch0, '0']
- [squelch_dmr_ch0, '0', demod_dmr_ch0, '0']
- [demod_dmr_ch0, '0', dsd_dmr_ch0, '0']
- [dsd_dmr_ch0, '0', aresamp_dmr_ch0, '0']
- [aresamp_dmr_ch0, '0', vol_dmr_ch0, '0']
- [pfb_channelizer_ccf_0, '1', resamp_iq_dmr_ch1, '0']
- [resamp_iq_dmr_ch1, '0', lpf_dmr_ch1, '0']
- [lpf_dmr_ch1, '0', squelch_dmr_ch1, '0']
- [squelch_dmr_ch1, '0', demod_dmr_ch1, '0']
- [demod_dmr_ch1, '0', dsd_dmr_ch1, '0']
- [dsd_dmr_ch1, '0', aresamp_dmr_ch1, '0']
- [aresamp_dmr_ch1, '0', vol_dmr_ch1, '0']
- [pfb_channelizer_ccf_0, '2', resamp_iq_dmr_ch2, '0']
- [resamp_iq_dmr_ch2, '0', lpf_dmr_ch2, '0']
- [lpf_dmr_ch2, '0', squelch_dmr_ch2, '0']
- [squelch_dmr_ch2, '0', demod_dmr_ch2, '0']
- [demod_dmr_ch2, '0', dsd_dmr_ch2, '0']
- [dsd_dmr_ch2, '0', aresamp_dmr_ch2, '0']
- [aresamp_dmr_ch2, '0', vol_dmr_ch2, '0']
- [pfb_channelizer_ccf_0, '3', resamp_iq_dmr_ch3, '0']
- [resamp_iq_dmr_ch3, '0', lpf_dmr_ch3, '0']
- [lpf_dmr_ch3, '0', squelch_dmr_ch3, '0']
- [squelch_dmr_ch3, '0', demod_dmr_ch3, '0']
- [demod_dmr_ch3, '0', dsd_dmr_ch3, '0']
- [dsd_dmr_ch3, '0', aresamp_dmr_ch3, '0']
- [aresamp_dmr_ch3, '0', vol_dmr_ch3, '0']
- [pfb_channelizer_ccf_0, '4', resamp_iq_dmr_ch4, '0']
- [resamp_iq_dmr_ch4, '0', lpf_dmr_ch4, '0']
- [lpf_dmr_ch4, '0', squelch_dmr_ch4, '0']
- [squelch_dmr_ch4, '0', demod_dmr_ch4, '0']
- [demod_dmr_ch4, '0', dsd_dmr_ch4, '0']
- [dsd_dmr_ch4, '0', aresamp_dmr_ch4, '0']
- [aresamp_dmr_ch4, '0', vol_dmr_ch4, '0']
- [pfb_channelizer_ccf_0, '5', resamp_iq_dmr_ch5, '0']
- [resamp_iq_dmr_ch5, '0', lpf_dmr_ch5, '0']
- [lpf_dmr_ch5, '0', squelch_dmr_ch5, '0']
- [squelch_dmr_ch5, '0', demod_dmr_ch5, '0']
- [demod_dmr_ch5, '0', dsd_dmr_ch5, '0']
- [dsd_dmr_ch5, '0', aresamp_dmr_ch5, '0']
- [aresamp_dmr_ch5, '0', vol_dmr_ch5, '0']
- [pfb_channelizer_ccf_0, '6', resamp_iq_dmr_ch6, '0']
- [resamp_iq_dmr_ch6, '0', lpf_dmr_ch6, '0']
- [lpf_dmr_ch6, '0', squelch_dmr_ch6, '0']
- [squelch_dmr_ch6, '0', demod_dmr_ch6, '0']
- [demod_dmr_ch6, '0', dsd_dmr_ch6, '0']
- [dsd_dmr_ch6, '0', aresamp_dmr_ch6, '0']
- [aresamp_dmr_ch6, '0', vol_dmr_ch6, '0']
- [pfb_channelizer_ccf_0, '7', resamp_iq_dmr_ch7, '0']
- [resamp_iq_dmr_ch7, '0', lpf_dmr_ch7, '0']
- [lpf_dmr_ch7, '0', squelch_dmr_ch7, '0']
- [squelch_dmr_ch7, '0', demod_dmr_ch7, '0']
- [demod_dmr_ch7, '0', dsd_dmr_ch7, '0']
- [dsd_dmr_ch7, '0', aresamp_dmr_ch7, '0']
- [aresamp_dmr_ch7, '0', vol_dmr_ch7, '0']
- [pfb_channelizer_ccf_0, '8', resamp_iq_dmr_ch8, '0']
- [resamp_iq_dmr_ch8, '0', lpf_dmr_ch8, '0']
- [lpf_dmr_ch8, '0', squelch_dmr_ch8, '0']
- [squelch_dmr_ch8, '0', demod_dmr_ch8, '0']
- [demod_dmr_ch8, '0', dsd_dmr_ch8, '0']
- [dsd_dmr_ch8, '0', aresamp_dmr_ch8, '0']
- [aresamp_dmr_ch8, '0', vol_dmr_ch8, '0']
- [pfb_channelizer_ccf_0, '9', resamp_iq_dmr_ch9, '0']
- [resamp_iq_dmr_ch9, '0', lpf_dmr_ch9, '0']
- [lpf_dmr_ch9, '0', squelch_dmr_ch9, '0']
- [squelch_dmr_ch9, '0', demod_dmr_ch9, '0']
- [demod_dmr_ch9, '0', dsd_dmr_ch9, '0']
- [dsd_dmr_ch9, '0', aresamp_dmr_ch9, '0']
- [aresamp_dmr_ch9, '0', vol_dmr_ch9, '0']
- [pfb_channelizer_ccf_0, '10', resamp_iq_dmr_ch10, '0']
- [resamp_iq_dmr_ch10, '0', lpf_dmr_ch10, '0']
- [lpf_dmr_ch10, '0', squelch_dmr_ch10, '0']
- [squelch_dmr_ch10, '0', demod_dmr_ch10, '0']
- [demod_dmr_ch10, '0', dsd_dmr_ch10, '0']
- [dsd_dmr_ch10, '0', aresamp_dmr_ch10, '0']
- [aresamp_dmr_ch10, '0', vol_dmr_ch10, '0']
- [pfb_channelizer_ccf_0, '11', resamp_iq_dmr_ch11, '0']
- [resamp_iq_dmr_ch11, '0', lpf_dmr_ch11, '0']
- [lpf_dmr_ch11, '0', squelch_dmr_ch11, '0']
- [squelch_dmr_ch11, '0', demod_dmr_ch11, '0']
- [demod_dmr_ch11, '0', dsd_dmr_ch11, '0']
- [dsd_dmr_ch11, '0', aresamp_dmr_ch11, '0']
- [aresamp_dmr_ch11, '0', vol_dmr_ch11, '0']
- [pfb_channelizer_ccf_0, '12', resamp_iq_dmr_ch12, '0']
- [resamp_iq_dmr_ch12, '0', lpf_dmr_ch12, '0']
- [lpf_dmr_ch12, '0', squelch_dmr_ch12, '0']
- [squelch_dmr_ch12, '0', demod_dmr_ch12, '0']
- [demod_dmr_ch12, '0', dsd_dmr_ch12, '0']
- [dsd_dmr_ch12, '0', aresamp_dmr_ch12, '0']
- [aresamp_dmr_ch12, '0', vol_dmr_ch12, '0']
- [pfb_channelizer_ccf_0, '13', resamp_iq_dmr_ch13, '0']
- [resamp_iq_dmr_ch13, '0', lpf_dmr_ch13, '0']
- [lpf_dmr_ch13, '0', squelch_dmr_ch13, '0']
- [squelch_dmr_ch13, '0', demod_dmr_ch13, '0']
- [demod_dmr_ch13, '0', dsd_dmr_ch13, '0']
- [dsd_dmr_ch13, '0', aresamp_dmr_ch13, '0']
- [aresamp_dmr_ch13, '0', vol_dmr_ch13, '0']
- [pfb_channelizer_ccf_0, '14', resamp_iq_dmr_ch14, '0']
- [resamp_iq_dmr_ch14, '0', lpf_dmr_ch14, '0']
- [lpf_dmr_ch14, '0', squelch_dmr_ch14, '0']
- [squelch_dmr_ch14, '0', demod_dmr_ch14, '0']
- [demod_dmr_ch14, '0', dsd_dmr_ch14, '0']
- [dsd_dmr_ch14, '0', aresamp_dmr_ch14, '0']
- [aresamp_dmr_ch14, '0', vol_dmr_ch14, '0']
- [pfb_channelizer_ccf_0, '15', resamp_iq_dmr_ch15, '0']
- [resamp_iq_dmr_ch15, '0', lpf_dmr_ch15, '0']
- [lpf_dmr_ch15, '0', squelch_dmr_ch15, '0']
- [squelch_dmr_ch15, '0', demod_dmr_ch15, '0']
- [demod_dmr_ch15, '0', dsd_dmr_ch15, '0']
- [dsd_dmr_ch15, '0', aresamp_dmr_ch15, '0']
- [aresamp_dmr_ch15, '0', vol_dmr_ch15, '0']
- [vol_dmr_ch0, '0', audio_mix_dmr, '0']
- [vol_dmr_ch1, '0', audio_mix_dmr, '1']
- [vol_dmr_ch2, '0', audio_mix_dmr, '2']
- [vol_dmr_ch3, '0', audio_mix_dmr, '3']
- [vol_dmr_ch4, '0', audio_mix_dmr, '4']
- [vol_dmr_ch5, '0', audio_mix_dmr, '5']
- [vol_dmr_ch6, '0', audio_mix_dmr, '6']
- [vol_dmr_ch7, '0', audio_mix_dmr, '7']
- [vol_dmr_ch8, '0', audio_mix_dmr, '8']
- [vol_dmr_ch9, '0', audio_mix_dmr, '9']
- [vol_dmr_ch10, '0', audio_mix_dmr, '10']
- [vol_dmr_ch11, '0', audio_mix_dmr, '11']
- [vol_dmr_ch12, '0', audio_mix_dmr, '12']
- [vol_dmr_ch13, '0', audio_mix_dmr, '13']
- [vol_dmr_ch14, '0', audio_mix_dmr, '14']
- [vol_dmr_ch15, '0', audio_mix_dmr, '15']
- [pfb_channelizer_ccf_0_1, '0', resamp_iq_nxdn_ch0, '0']
- [resamp_iq_nxdn_ch0, '0', lpf_nxdn_ch0, '0']
- [lpf_nxdn_ch0, '0', squelch_nxdn_ch0, '0']
- [squelch_nxdn_ch0, '0', demod_nxdn_ch0, '0']
- [demod_nxdn_ch0, '0', dsd_nxdn_ch0, '0']
- [dsd_nxdn_ch0, '0', aresamp_nxdn_ch0, '0']
- [aresamp_nxdn_ch0, '0', vol_nxdn_ch0, '0']
- [pfb_channelizer_ccf_0_1, '1', resamp_iq_nxdn_ch1, '0']
- [resamp_iq_nxdn_ch1, '0', lpf_nxdn_ch1, '0']
- [lpf_nxdn_ch1, '0', squelch_nxdn_ch1, '0']
- [squelch_nxdn_ch1, '0', demod_nxdn_ch1, '0']
- [demod_nxdn_ch1, '0', dsd_nxdn_ch1, '0']
- [dsd_nxdn_ch1, '0', aresamp_nxdn_ch1, '0']
- [aresamp_nxdn_ch1, '0', vol_nxdn_ch1, '0']
- [pfb_channelizer_ccf_0_1, '2', resamp_iq_nxdn_ch2, '0']
- [resamp_iq_nxdn_ch2, '0', lpf_nxdn_ch2, '0']
- [lpf_nxdn_ch2, '0', squelch_nxdn_ch2, '0']
- [squelch_nxdn_ch2, '0', demod_nxdn_ch2, '0']
- [demod_nxdn_ch2, '0', dsd_nxdn_ch2, '0']
- [dsd_nxdn_ch2, '0', aresamp_nxdn_ch2, '0']
- [aresamp_nxdn_ch2, '0', vol_nxdn_ch2, '0']
- [pfb_channelizer_ccf_0_1, '3', resamp_iq_nxdn_ch3, '0']
- [resamp_iq_nxdn_ch3, '0', lpf_nxdn_ch3, '0']
- [lpf_nxdn_ch3, '0', squelch_nxdn_ch3, '0']
- [squelch_nxdn_ch3, '0', demod_nxdn_ch3, '0']
- [demod_nxdn_ch3, '0', dsd_nxdn_ch3, '0']
- [dsd_nxdn_ch3, '0', aresamp_nxdn_ch3, '0']
- [aresamp_nxdn_ch3, '0', vol_nxdn_ch3, '0']
- [pfb_channelizer_ccf_0_1, '4', resamp_iq_nxdn_ch4, '0']
- [resamp_iq_nxdn_ch4, '0', lpf_nxdn_ch4, '0']
- [lpf_nxdn_ch4, '0', squelch_nxdn_ch4, '0']
- [squelch_nxdn_ch4, '0', demod_nxdn_ch4, '0']
- [demod_nxdn_ch4, '0', dsd_nxdn_ch4, '0']
- [dsd_nxdn_ch4, '0', aresamp_nxdn_ch4, '0']
- [aresamp_nxdn_ch4, '0', vol_nxdn_ch4, '0']
- [pfb_channelizer_ccf_0_1, '5', resamp_iq_nxdn_ch5, '0']
- [resamp_iq_nxdn_ch5, '0', lpf_nxdn_ch5, '0']
- [lpf_nxdn_ch5, '0', squelch_nxdn_ch5, '0']
- [squelch_nxdn_ch5, '0', demod_nxdn_ch5, '0']
- [demod_nxdn_ch5, '0', dsd_nxdn_ch5, '0']
- [dsd_nxdn_ch5, '0', aresamp_nxdn_ch5, '0']
- [aresamp_nxdn_ch5, '0', vol_nxdn_ch5, '0']
- [pfb_channelizer_ccf_0_1, '6', resamp_iq_nxdn_ch6, '0']
- [resamp_iq_nxdn_ch6, '0', lpf_nxdn_ch6, '0']
- [lpf_nxdn_ch6, '0', squelch_nxdn_ch6, '0']
- [squelch_nxdn_ch6, '0', demod_nxdn_ch6, '0']
- [demod_nxdn_ch6, '0', dsd_nxdn_ch6, '0']
- [dsd_nxdn_ch6, '0', aresamp_nxdn_ch6, '0']
- [aresamp_nxdn_ch6, '0', vol_nxdn_ch6, '0']
- [pfb_channelizer_ccf_0_1, '7', resamp_iq_nxdn_ch7, '0']
- [resamp_iq_nxdn_ch7, '0', lpf_nxdn_ch7, '0']
- [lpf_nxdn_ch7, '0', squelch_nxdn_ch7, '0']
- [squelch_nxdn_ch7, '0', demod_nxdn_ch7, '0']
- [demod_nxdn_ch7, '0', dsd_nxdn_ch7, '0']
- [dsd_nxdn_ch7, '0', aresamp_nxdn_ch7, '0']
- [aresamp_nxdn_ch7, '0', vol_nxdn_ch7, '0']
- [pfb_channelizer_ccf_0_1, '8', resamp_iq_nxdn_ch8, '0']
- [resamp_iq_nxdn_ch8, '0', lpf_nxdn_ch8, '0']
- [lpf_nxdn_ch8, '0', squelch_nxdn_ch8, '0']
- [squelch_nxdn_ch8, '0', demod_nxdn_ch8, '0']
- [demod_nxdn_ch8, '0', dsd_nxdn_ch8, '0']
- [dsd_nxdn_ch8, '0', aresamp_nxdn_ch8, '0']
- [aresamp_nxdn_ch8, '0', vol_nxdn_ch8, '0']
- [pfb_channelizer_ccf_0_1, '9', resamp_iq_nxdn_ch9, '0']
- [resamp_iq_nxdn_ch9, '0', lpf_nxdn_ch9, '0']
- [lpf_nxdn_ch9, '0', squelch_nxdn_ch9, '0']
- [squelch_nxdn_ch9, '0', demod_nxdn_ch9, '0']
- [demod_nxdn_ch9, '0', dsd_nxdn_ch9, '0']
- [dsd_nxdn_ch9, '0', aresamp_nxdn_ch9, '0']
- [aresamp_nxdn_ch9, '0', vol_nxdn_ch9, '0']
- [pfb_channelizer_ccf_0_1, '10', resamp_iq_nxdn_ch10, '0']
- [resamp_iq_nxdn_ch10, '0', lpf_nxdn_ch10, '0']
- [lpf_nxdn_ch10, '0', squelch_nxdn_ch10, '0']
- [squelch_nxdn_ch10, '0', demod_nxdn_ch10, '0']
- [demod_nxdn_ch10, '0', dsd_nxdn_ch10, '0']
- [dsd_nxdn_ch10, '0', aresamp_nxdn_ch10, '0']
- [aresamp_nxdn_ch10, '0', vol_nxdn_ch10, '0']
- [pfb_channelizer_ccf_0_1, '11', resamp_iq_nxdn_ch11, '0']
- [resamp_iq_nxdn_ch11, '0', lpf_nxdn_ch11, '0']
- [lpf_nxdn_ch11, '0', squelch_nxdn_ch11, '0']
- [squelch_nxdn_ch11, '0', demod_nxdn_ch11, '0']
- [demod_nxdn_ch11, '0', dsd_nxdn_ch11, '0']
- [dsd_nxdn_ch11, '0', aresamp_nxdn_ch11, '0']
- [aresamp_nxdn_ch11, '0', vol_nxdn_ch11, '0']
- [pfb_channelizer_ccf_0_1, '12', resamp_iq_nxdn_ch12, '0']
- [resamp_iq_nxdn_ch12, '0', lpf_nxdn_ch12, '0']
- [lpf_nxdn_ch12, '0', squelch_nxdn_ch12, '0']
- [squelch_nxdn_ch12, '0', demod_nxdn_ch12, '0']
- [demod_nxdn_ch12, '0', dsd_nxdn_ch12, '0']
- [dsd_nxdn_ch12, '0', aresamp_nxdn_ch12, '0']
- [aresamp_nxdn_ch12, '0', vol_nxdn_ch12, '0']
- [pfb_channelizer_ccf_0_1, '13', resamp_iq_nxdn_ch13, '0']
- [resamp_iq_nxdn_ch13, '0', lpf_nxdn_ch13, '0']
- [lpf_nxdn_ch13, '0', squelch_nxdn_ch13, '0']
- [squelch_nxdn_ch13, '0', demod_nxdn_ch13, '0']
- [demod_nxdn_ch13, '0', dsd_nxdn_ch13, '0']
- [dsd_nxdn_ch13, '0', aresamp_nxdn_ch13, '0']
- [aresamp_nxdn_ch13, '0', vol_nxdn_ch13, '0']
- [pfb_channelizer_ccf_0_1, '14', resamp_iq_nxdn_ch14, '0']
- [resamp_iq_nxdn_ch14, '0', lpf_nxdn_ch14, '0']
- [lpf_nxdn_ch14, '0', squelch_nxdn_ch14, '0']
- [squelch_nxdn_ch14, '0', demod_nxdn_ch14, '0']
- [demod_nxdn_ch14, '0', dsd_nxdn_ch14, '0']
- [dsd_nxdn_ch14, '0', aresamp_nxdn_ch14, '0']
- [aresamp_nxdn_ch14, '0', vol_nxdn_ch14, '0']
- [pfb_channelizer_ccf_0_1, '15', resamp_iq_nxdn_ch15, '0']
- [resamp_iq_nxdn_ch15, '0', lpf_nxdn_ch15, '0']
- [lpf_nxdn_ch15, '0', squelch_nxdn_ch15, '0']
- [squelch_nxdn_ch15, '0', demod_nxdn_ch15, '0']
- [demod_nxdn_ch15, '0', dsd_nxdn_ch15, '0']
- [dsd_nxdn_ch15, '0', aresamp_nxdn_ch15, '0']
- [aresamp_nxdn_ch15, '0', vol_nxdn_ch15, '0']
- [vol_nxdn_ch0, '0', audio_mix_nxdn, '0']
- [vol_nxdn_ch1, '0', audio_mix_nxdn, '1']
- [vol_nxdn_ch2, '0', audio_mix_nxdn, '2']
- [vol_nxdn_ch3, '0', audio_mix_nxdn, '3']
- [vol_nxdn_ch4, '0', audio_mix_nxdn, '4']
- [vol_nxdn_ch5, '0', audio_mix_nxdn, '5']
- [vol_nxdn_ch6, '0', audio_mix_nxdn, '6']
- [vol_nxdn_ch7, '0', audio_mix_nxdn, '7']
- [vol_nxdn_ch8, '0', audio_mix_nxdn, '8']
- [vol_nxdn_ch9, '0', audio_mix_nxdn, '9']
- [vol_nxdn_ch10, '0', audio_mix_nxdn, '10']
- [vol_nxdn_ch11, '0', audio_mix_nxdn, '11']
- [vol_nxdn_ch12, '0', audio_mix_nxdn, '12']
- [vol_nxdn_ch13, '0', audio_mix_nxdn, '13']
- [vol_nxdn_ch14, '0', audio_mix_nxdn, '14']
- [vol_nxdn_ch15, '0', audio_mix_nxdn, '15']
- [pfb_channelizer_ccf_0_0, '0', resamp_iq_p25_ch0, '0']
- [resamp_iq_p25_ch0, '0', lpf_p25_ch0, '0']
- [lpf_p25_ch0, '0', squelch_p25_ch0, '0']
- [squelch_p25_ch0, '0', demod_p25_ch0, '0']
- [demod_p25_ch0, '0', dsd_p25_ch0, '0']
- [dsd_p25_ch0, '0', aresamp_p25_ch0, '0']
- [aresamp_p25_ch0, '0', vol_p25_ch0, '0']
- [pfb_channelizer_ccf_0_0, '1', resamp_iq_p25_ch1, '0']
- [resamp_iq_p25_ch1, '0', lpf_p25_ch1, '0']
- [lpf_p25_ch1, '0', squelch_p25_ch1, '0']
- [squelch_p25_ch1, '0', demod_p25_ch1, '0']
- [demod_p25_ch1, '0', dsd_p25_ch1, '0']
- [dsd_p25_ch1, '0', aresamp_p25_ch1, '0']
- [aresamp_p25_ch1, '0', vol_p25_ch1, '0']
- [pfb_channelizer_ccf_0_0, '2', resamp_iq_p25_ch2, '0']
- [resamp_iq_p25_ch2, '0', lpf_p25_ch2, '0']
- [lpf_p25_ch2, '0', squelch_p25_ch2, '0']
- [squelch_p25_ch2, '0', demod_p25_ch2, '0']
- [demod_p25_ch2, '0', dsd_p25_ch2, '0']
- [dsd_p25_ch2, '0', aresamp_p25_ch2, '0']
- [aresamp_p25_ch2, '0', vol_p25_ch2, '0']
- [pfb_channelizer_ccf_0_0, '3', resamp_iq_p25_ch3, '0']
- [resamp_iq_p25_ch3, '0', lpf_p25_ch3, '0']
- [lpf_p25_ch3, '0', squelch_p25_ch3, '0']
- [squelch_p25_ch3, '0', demod_p25_ch3, '0']
- [demod_p25_ch3, '0', dsd_p25_ch3, '0']
- [dsd_p25_ch3, '0', aresamp_p25_ch3, '0']
- [aresamp_p25_ch3, '0', vol_p25_ch3, '0']
- [pfb_channelizer_ccf_0_0, '4', resamp_iq_p25_ch4, '0']
- [resamp_iq_p25_ch4, '0', lpf_p25_ch4, '0']
- [lpf_p25_ch4, '0', squelch_p25_ch4, '0']
- [squelch_p25_ch4, '0', demod_p25_ch4, '0']
- [demod_p25_ch4, '0', dsd_p25_ch4, '0']
- [dsd_p25_ch4, '0', aresamp_p25_ch4, '0']
- [aresamp_p25_ch4, '0', vol_p25_ch4, '0']
- [pfb_channelizer_ccf_0_0, '5', resamp_iq_p25_ch5, '0']
- [resamp_iq_p25_ch5, '0', lpf_p25_ch5, '0']
- [lpf_p25_ch5, '0', squelch_p25_ch5, '0']
- [squelch_p25_ch5, '0', demod_p25_ch5, '0']
- [demod_p25_ch5, '0', dsd_p25_ch5, '0']
- [dsd_p25_ch5, '0', aresamp_p25_ch5, '0']
- [aresamp_p25_ch5, '0', vol_p25_ch5, '0']
- [pfb_channelizer_ccf_0_0, '6', resamp_iq_p25_ch6, '0']
- [resamp_iq_p25_ch6, '0', lpf_p25_ch6, '0']
- [lpf_p25_ch6, '0', squelch_p25_ch6, '0']
- [squelch_p25_ch6, '0', demod_p25_ch6, '0']
- [demod_p25_ch6, '0', dsd_p25_ch6, '0']
- [dsd_p25_ch6, '0', aresamp_p25_ch6, '0']
- [aresamp_p25_ch6, '0', vol_p25_ch6, '0']
- [pfb_channelizer_ccf_0_0, '7', resamp_iq_p25_ch7, '0']
- [resamp_iq_p25_ch7, '0', lpf_p25_ch7, '0']
- [lpf_p25_ch7, '0', squelch_p25_ch7, '0']
- [squelch_p25_ch7, '0', demod_p25_ch7, '0']
- [demod_p25_ch7, '0', dsd_p25_ch7, '0']
- [dsd_p25_ch7, '0', aresamp_p25_ch7, '0']
- [aresamp_p25_ch7, '0', vol_p25_ch7, '0']
- [pfb_channelizer_ccf_0_0, '8', resamp_iq_p25_ch8, '0']
- [resamp_iq_p25_ch8, '0', lpf_p25_ch8, '0']
- [lpf_p25_ch8, '0', squelch_p25_ch8, '0']
- [squelch_p25_ch8, '0', demod_p25_ch8, '0']
- [demod_p25_ch8, '0', dsd_p25_ch8, '0']
- [dsd_p25_ch8, '0', aresamp_p25_ch8, '0']
- [aresamp_p25_ch8, '0', vol_p25_ch8, '0']
- [pfb_channelizer_ccf_0_0, '9', resamp_iq_p25_ch9, '0']
- [resamp_iq_p25_ch9, '0', lpf_p25_ch9, '0']
- [lpf_p25_ch9, '0', squelch_p25_ch9, '0']
- [squelch_p25_ch9, '0', demod_p25_ch9, '0']
- [demod_p25_ch9, '0', dsd_p25_ch9, '0']
- [dsd_p25_ch9, '0', aresamp_p25_ch9, '0']
- [aresamp_p25_ch9, '0', vol_p25_ch9, '0']
- [vol_p25_ch0, '0', audio_mix_p25, '0']
- [vol_p25_ch1, '0', audio_mix_p25, '1']
- [vol_p25_ch2, '0', audio_mix_p25, '2']
- [vol_p25_ch3, '0', audio_mix_p25, '3']
- [vol_p25_ch4, '0', audio_mix_p25, '4']
- [vol_p25_ch5, '0', audio_mix_p25, '5']
- [vol_p25_ch6, '0', audio_mix_p25, '6']
- [vol_p25_ch7, '0', audio_mix_p25, '7']
- [vol_p25_ch8, '0', audio_mix_p25, '8']
- [vol_p25_ch9, '0', audio_mix_p25, '9']
- [audio_mix_dmr, '0', blocks_add_master, '0']
- [audio_mix_nxdn, '0', blocks_add_master, '1']
- [audio_mix_p25, '0', blocks_add_master, '2']
- [blocks_add_master, '0', audio_sink_0, '0']

metadata:
  file_format: 1
