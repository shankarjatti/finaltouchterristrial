options:
  parameters:
    id: hackrf_replay
    title: HackRF IQ replay (TX)
    author: SecureCOM
    description: Replay a recorded IQ .wav through a HackRF on a chosen frequency. Use a cable + 30-40 dB attenuator, never an antenna. Amp off, stops after `duration`.
    category: '[SecureCOM]'
    generate_options: no_gui
    run_options: run
    output_language: python
  states: {}

blocks:
- name: imp_fractions
  id: import
  parameters:
    imports: |-
      from fractions import Fraction
      import math
  states: {}
- name: wav_file
  id: parameter
  parameters:
    label: 'IQ .wav file (stereo: I=left, Q=right)'
    value: /home/shankar/Downloads/tutorials/delhi_testing/all_protocols_wav_samples/NXDN/NXDN96 IQ.wav
    type: str
    short_id: f
  states: {}
- name: in_rate
  id: parameter
  parameters:
    label: Sample rate of the .wav (Hz)
    value: '48000'
    type: intx
    short_id: r
    comment: NXDN96/NXDN48/TETRA IQ.wav = 48000, AIS sample = 250000, DMR/P25 72k files = 72125
  states: {}
- name: freq
  id: parameter
  parameters:
    label: On-air frequency (Hz)
    value: 451.09375e6
    type: eng_float
    short_id: F
    comment: NXDN96 451.09375e6, P25 450.09375e6, TETRA 420e6, AIS centre 162.000e6
  states: {}
- name: ppm
  id: parameter
  parameters:
    label: HackRF crystal error (ppm)
    value: '-6.24'
    type: eng_float
    short_id: p
    comment: measured on this bench's HackRF; 0 for no correction
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    label: HackRF TX VGA gain (dB, 0-47)
    value: '0'
    type: intx
    short_id: g
    comment: start at 0 and raise; the +14 dB RF amp is permanently OFF
  states: {}
- name: duration
  id: parameter
  parameters:
    label: Stop after (seconds)
    value: '60'
    type: eng_float
    short_id: d
  states: {}
- name: swap_iq
  id: parameter
  parameters:
    label: Swap I/Q (0 = no, 1 = yes)
    value: '0'
    type: intx
    short_id: s
    comment: TETRA IQ.wav stores Q left / I right -> 1
  states: {}
- name: offset
  id: parameter
  parameters:
    label: HackRF offset below the carrier (Hz)
    value: 500e3
    type: eng_float
    short_id: o
  states: {}
- name: scale
  id: parameter
  parameters:
    label: Digital level before the DAC
    value: '0.5'
    type: eng_float
    short_id: l
  states: {}
- name: hackrf_rate
  id: parameter
  parameters:
    label: HackRF sample rate (2e6 narrowband; e.g. 16e6 for ADS-B)
    value: 2e6
    type: eng_float
    short_id: R
    comment: 'above 2e6 the wav goes straight to this rate (no 200 kSps stage); ADS-B: 16e6 with offset 4e6'
  states: {}
- name: base_rate
  id: variable
  parameters:
    value: 200000 if hackrf_rate == 2e6 else int(hackrf_rate)
    comment: 'stage-1 target: 200 kSps (narrowband) or straight to hackrf_rate (wideband)'
  states: {}
- name: r1
  id: variable
  parameters:
    value: Fraction(int(base_rate), int(in_rate)).limit_denominator(1000)
    comment: 'stage-1 resample ratio: wav rate -> base_rate'
  states: {}
- name: interp2
  id: variable
  parameters:
    value: int(hackrf_rate // base_rate)
    comment: stage-2 interpolation (x10 narrowband, x1 wideband)
  states: {}
- name: tx_bw
  id: variable
  parameters:
    value: 1.75e6 if hackrf_rate == 2e6 else 0.75 * hackrf_rate
    comment: 'HackRF baseband filter: must pass the signal at +offset'
  states: {}
- name: tune_freq
  id: variable
  parameters:
    value: freq / (1 + ppm * 1e-6) - offset
    comment: 'HackRF centre: crystal-corrected and moved down by the offset'
  states: {}
- name: wav
  id: blocks_wavfile_source
  parameters:
    file: wav_file
    repeat: 'True'
    nchan: '2'
    comment: loops forever; Head stops it
  states: {}
- name: iq_straight
  id: blocks_float_to_complex
  parameters:
    comment: I=left, Q=right
  states: {}
- name: iq_swapped
  id: blocks_float_to_complex
  parameters:
    comment: I=right, Q=left
  states: {}
- name: iq_select
  id: blocks_selector
  parameters:
    type: complex
    num_inputs: '2'
    num_outputs: '1'
    input_index: swap_iq
    output_index: '0'
    enabled: 'True'
  states: {}
- name: to_200k
  id: rational_resampler_xxx
  parameters:
    type: ccc
    interp: r1.numerator
    decim: r1.denominator
    fbw: '0.4'
    comment: wav rate -> base_rate
  states: {}
- name: to_2M
  id: rational_resampler_xxx
  parameters:
    type: ccc
    interp: interp2
    decim: '1'
    fbw: '0.4'
    comment: base_rate -> hackrf_rate
  states: {}
- name: shift
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * math.pi * offset / hackrf_rate
    comment: moves the signal up by `offset`
  states: {}
- name: level
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: scale
    comment: keeps the HackRF DAC from clipping
  states: {}
- name: stop_after
  id: blocks_head
  parameters:
    type: complex
    num_items: int(duration * hackrf_rate)
    comment: 'timed stop: the flowgraph ends by itself'
  states: {}
- name: hackrf_tx
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    sync: sync
    sample_rate: hackrf_rate
    freq0: tune_freq
    gain0: '0'
    if_gain0: tx_gain
    bb_gain0: '0'
    bw0: tx_bw
    comment: RF (amp) gain 0 = OFF. IF gain = TX VGA.
  states: {}
- name: safety_note
  id: note
  parameters:
    note: 'SAFETY: transmit only through a CABLE + 30-40 dB attenuator into the receiver. Never into an antenna. TX gain starts at 0, RF amp is off, the flowgraph stops itself after `duration` seconds.'
  states: {}

connections:
- [wav, '0', iq_straight, '0']
- [wav, '1', iq_straight, '1']
- [wav, '1', iq_swapped, '0']
- [wav, '0', iq_swapped, '1']
- [iq_straight, '0', iq_select, '0']
- [iq_swapped, '0', iq_select, '1']
- [iq_select, '0', to_200k, '0']
- [to_200k, '0', to_2M, '0']
- [to_2M, '0', shift, '0']
- [shift, '0', level, '0']
- [level, '0', stop_after, '0']
- [stop_after, '0', hackrf_tx, '0']

metadata:
  file_format: 1
  grc_version: 3.10.1.1
